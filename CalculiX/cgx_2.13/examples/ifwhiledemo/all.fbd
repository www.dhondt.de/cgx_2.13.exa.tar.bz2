 PNT P100     0.00000        1.00000        0.00000
 PNT P200     0.00000        2.00000        0.00000
 PNT P300     0.00000        3.00000        0.00000
 PNT P400     0.00000        4.00000        0.00000
 PNT P101     0.00000        1.00000        1.00000
 PNT P201     0.00000        2.00000        1.00000
 PNT P301     0.00000        3.00000        1.00000
 PNT P401     0.00000        4.00000        1.00000
 PNT P110     1.00000        1.00000        0.00000
 PNT P210     1.00000        2.00000        0.00000
 PNT P310     1.00000        3.00000        0.00000
 PNT P410     1.00000        4.00000        0.00000
 PNT P111     1.00000        1.00000        1.00000
 PNT P211     1.00000        2.00000        1.00000
 PNT P311     1.00000        3.00000        1.00000
 PNT P411     1.00000        4.00000        1.00000
 PNT P120     2.00000        1.00000        0.00000
 PNT P220     2.00000        2.00000        0.00000
 PNT P320     2.00000        3.00000        0.00000
 PNT P420     2.00000        4.00000        0.00000
 PNT P121     2.00000        1.00000        1.00000
 PNT P221     2.00000        2.00000        1.00000
 PNT P321     2.00000        3.00000        1.00000
 PNT P421     2.00000        4.00000        1.00000
 PNT P130     3.00000        1.00000        0.00000
 PNT P230     3.00000        2.00000        0.00000
 PNT P330     3.00000        3.00000        0.00000
 PNT P430     3.00000        4.00000        0.00000
 PNT P131     3.00000        1.00000        1.00000
 PNT P231     3.00000        2.00000        1.00000
 PNT P331     3.00000        3.00000        1.00000
 PNT P431     3.00000        4.00000        1.00000
 VALU vp P
 VALU vx 4.000000e+00
 VALU v2 4
 VALU v3 1
 VALU vy 4
 VALU vz 1
 VALU p1 P430
 VALU p2 P431
 SETA S1 p P100
 SETA S1 p P200
 SETA S1 p P300
 SETA S1 p P400
 SETA S1 p P110
 SETA S1 p P210
 SETA S1 p P310
 SETA S1 p P410
 SETA S1 p P120
 SETA S1 p P220
 SETA S1 p P320
 SETA S1 p P420
 SETA S1 p P130
 SETA S1 p P230
 SETA S1 p P330
 SETA S1 p P430
 SETA S2 p P101
 SETA S2 p P201
 SETA S2 p P301
 SETA S2 p P401
 SETA S2 p P111
 SETA S2 p P211
 SETA S2 p P311
 SETA S2 p P411
 SETA S2 p P121
 SETA S2 p P221
 SETA S2 p P321
 SETA S2 p P421
 SETA S2 p P131
 SETA S2 p P231
 SETA S2 p P331
 SETA S2 p P431
 plot pa S1 r
 plus pa S2 b
 plus pa S2 b
 plus pa S2 b
