 PNT D001     0.00000        0.00000        1.00000
 PNT D002     1.00000        0.00000        1.00000
 PNT D003     0.50000        0.00000        2.00000
 PNT D004     1.00000        0.00000        2.00000
 PNT D005     0.50000        0.00000        5.00000
 PNT D006     0.00000        0.00000        5.00000
 PNT D00C     0.00000       -0.08716        0.99619
 PNT D00D     1.00000       -0.08716        0.99619
 PNT D00E     0.50000       -0.17431        1.99239
 PNT D00F     1.00000       -0.17431        1.99239
 PNT D00G     0.50000       -0.43578        4.98097
 PNT D00H     0.00000       -0.43578        4.98097
 PNT D00N     0.00000        0.00000        0.00000
 PNT D00O     1.00000        0.00000        0.00000
 PNT D00P     0.50000        0.00000        0.00000
 PNT D00Q     1.00000        0.00000        0.00000
 PNT D00R     0.50000        0.00000        0.00000
 PNT D00S     0.00000        0.00000        0.00000
 PNT D00Y     0.00000       -0.17365        0.98481
 PNT D00Z     1.00000       -0.17365        0.98481
 PNT D010     0.50000       -0.34730        1.96962
 PNT D011     1.00000       -0.34730        1.96962
 PNT D012     0.50000       -0.86824        4.92404
 PNT D013     0.00000       -0.86824        4.92404
 PNT D019     0.00000        0.00000        0.00000
 PNT D01A     1.00000        0.00000        0.00000
 PNT D01B     0.50000        0.00000        0.00000
 PNT D01C     1.00000        0.00000        0.00000
 PNT D01D     0.50000        0.00000        0.00000
 PNT D01E     0.00000        0.00000        0.00000
 PNT D01K     0.50000       -0.31118        3.55673
 PNT D007     0.50000        0.00000        5.00000
 PNT D008     0.50000        0.00000        1.97000
 PNT D009     5.00000        0.00000        1.97000
 PNT D00A     5.00000        0.00000        2.27000
 PNT D00B     0.80000        0.00000        2.27000
 PNT D00I     0.80000        0.00000        5.00000
 PNT D00J     0.50000       -0.43578        4.98097
 PNT D00K     0.50000       -0.17170        1.96250
 PNT D00L     5.00000       -0.17170        1.96250
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 LINE L001 D001 D002 104
 LINE L002 D002 D004 104
 LINE L003 D004 D003 104
 LINE L004 D003 D005 104
 LINE L005 D005 D006 104
 LINE L006 D006 D001 104
 LINE L007 D001 D003 104
 LINE L00F D00C D00D 104
 LINE L00G D00D D00F 104
 LINE L00H D00F D00E 104
 LINE L00J D00G D00H 104
 LINE L00K D00H D00C 104
 LINE L00L D00C D00E 104
 LINE L00T D001 D00C D00N 104
 LINE L00U D002 D00D D00O 104
 LINE L00V D003 D00E D00P 104
 LINE L00W D004 D00F D00Q 104
 LINE L00X D005 D00G D00R 104
 LINE L00Y D006 D00H D00S 104
 LINE L014 D00Y D00Z 104
 LINE L015 D00Z D011 104
 LINE L016 D011 D010 104
 LINE L017 D010 D012 104
 LINE L018 D012 D013 104
 LINE L019 D013 D00Y 104
 LINE L01A D00Y D010 104
 LINE L01I D00C D00Y D019 104
 LINE L01J D00D D00Z D01A 104
 LINE L01K D00E D010 D01B 104
 LINE L01L D00F D011 D01C 104
 LINE L01M D00G D012 D01D 104
 LINE L01N D00H D013 D01E 104
 LINE L01T D00E D01K 102
 LINE L01U D01K D00G 102
 LINE L008 D007 D008 104
 LINE L009 D008 D009 104
 LINE L00A D009 D00A 104
 LINE L00B D00A D00B 104
 LINE L00C D00B D00I 104
 LINE L00D D00I D007 104
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 LCMB C001  + L01T + L01U
 LCMB C002  + L00I + L01W
 GSUR A001 + BLEND - L007 + L001 + L002 + L003
 GSUR A002 + BLEND + L006 + L007 + L004 + L005
 GSUR A005 + BLEND - L00L + L00F + L00G + L00H
 GSUR A006 + BLEND + L00K + L00L + C001 + L00J
 GSUR A009 + BLEND - L001 + L00T + L00F - L00U
 GSUR A00A + BLEND - L002 + L00U + L00G - L00W
 GSUR A00B + BLEND - L003 + L00W + L00H - L00V
 GSUR A00C + BLEND - L004 + L00V + C001 - L00X
 GSUR A00D + BLEND - L005 + L00X + L00J - L00Y
 GSUR A00E + BLEND - L006 + L00Y + L00K - L00T
 GSUR A00F + BLEND - L007 + L00T + L00L - L00V
 GSUR A00N + BLEND - L01A + L014 + L015 + L016
 GSUR A00O + BLEND + L019 + L01A + L017 + L018
 GSUR A00R + BLEND - L00F + L01I + L014 - L01J
 GSUR A00S + BLEND - L00G + L01J + L015 - L01L
 GSUR A00T + BLEND - L00H + L01L + L016 - L01K
 GSUR A00U + BLEND - C001 + L01K + L017 - L01M
 GSUR A00V + BLEND - L00J + L01M + L018 - L01N
 GSUR A00W + BLEND - L00K + L01N + L019 - L01I
 GSUR A00X + BLEND - L00L + L01I + L01A - L01K
 GSUR A003 + BLEND + L008 + L00E + L00C + L00D
 GSUR A004 + BLEND - L00E + L009 + L00A + L00B
 GSUR A007 + BLEND + C002 + L00R + L00P + L00Q
 GSUR A008 + BLEND - L00R + L00M + L00N + L00O
 GSUR A00G + BLEND - L008 + L00S + C002 - L00Z
 GSUR A00H + BLEND - L009 + L00Z + L00M - L010
 GSUR A00I + BLEND - L00A + L010 + L00N - L011
 GSUR A00J + BLEND - L00B + L011 + L00O - L012
 GSUR A00K + BLEND - L00C + L012 + L00P - L013
 GSUR A00L + BLEND - L00D + L013 + L00Q - L00S
 GSUR A00M + BLEND - L00E + L00Z + L00R - L012
 GSUR A00P + BLEND + L01B + L01H + L01F + L01G
 GSUR A00Q + BLEND - L01H + L01C + L01D + L01E
 GSUR A00Y + BLEND - C002 + L01O + L01B - L01P
 GSUR A00Z + BLEND - L00M + L01P + L01C - L01Q
 GSUR A010 + BLEND - L00N + L01Q + L01D - L01R
 GSUR A011 + BLEND - L00O + L01R + L01E - L01S
 GSUR A012 + BLEND - L00P + L01S + L01F - L01V
 GSUR A013 + BLEND - L00Q + L01V + L01G - L01O
 GSUR A014 + BLEND - L00R + L01P + L01H - L01S
 GBOD B001 NORM - A001 + A005 - A00A - A009 + A00F - A00B
 GBOD B002 NORM - A002 + A006 - A00C - A00F - A00E - A00D
 GBOD B005 NORM - A005 + A00N - A00S - A00R + A00X - A00T
 GBOD B006 NORM - A006 + A00O - A00U - A00X - A00W - A00V
 GBOD B003 NORM - A003 + A007 - A00K - A00M - A00G - A00L
 GBOD B004 NORM - A004 + A008 - A00I - A00H + A00M - A00J
 GBOD B007 NORM - A007 + A00P - A012 - A014 - A00Y - A013
 GBOD B008 NORM - A008 + A00Q - A010 - A00Z + A014 - A011
 SETA SPCB1 p D00C
 SETA SPCB1 p D00D
 SETA SPCB1 p D00N
 SETA SPCB1 p D00O
 SETA SPCB1 p D00Y
 SETA SPCB1 p D00Z
 SETA SPCB1 p D019
 SETA SPCB1 p D01A
 SETA SPCB1 l L00F
 SETA SPCB1 l L00T
 SETA SPCB1 l L00U
 SETA SPCB1 l L014
 SETA SPCB1 l L01I
 SETA SPCB1 l L01J
 SETA SPCB1 s A009
 SETA SPCB1 s A00R
 SETA B1 p D001
 SETA B1 p D002
 SETA B1 p D003
 SETA B1 p D004
 SETA B1 p D005
 SETA B1 p D006
 SETA B1 p D00C
 SETA B1 p D00D
 SETA B1 p D00E
 SETA B1 p D00F
 SETA B1 p D00G
 SETA B1 p D00H
 SETA B1 p D00N
 SETA B1 p D00O
 SETA B1 p D00P
 SETA B1 p D00Q
 SETA B1 p D00R
 SETA B1 p D00S
 SETA B1 p D00Y
 SETA B1 p D00Z
 SETA B1 p D010
 SETA B1 p D011
 SETA B1 p D012
 SETA B1 p D013
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 ELTY all HE20R
 plot sa all m
 plus si all
