 PNT P001    -0.10000        0.00000       -0.00000
 PNT P002    -0.00000       -0.10000       -0.00000
 PNT P003    -0.00000        0.00000       -0.00000
 PNT P004    -0.07071       -0.07071       -0.00000
 PNT P005    -0.10000        0.00000        0.20000
 PNT P006    -0.00000       -0.10000        0.20000
 PNT P007    -0.00000        0.00000        0.20000
 PNT P008    -0.07071       -0.07071        0.20000
 PNT P009    -0.07071        0.00000        0.27071
 PNT P00A    -0.05000       -0.05000        0.27071
 PNT P00C    -0.00000       -0.07071        0.27071
 PNT P00E    -0.00000        0.00000        0.27071
 PNT P00G    -0.01000        0.00000        0.29950
 PNT P00I    -0.00707       -0.00707        0.29950
 PNT P00J    -0.00000       -0.01000        0.29950
 PNT P00K    -0.00000        0.00000        0.30000
 PNT P00L    -0.30000        0.00000       -0.00000
 PNT P00N    -0.30000       -0.30000       -0.00000
 PNT P00O    -0.00000       -0.30000       -0.00000
 PNT P00P    -0.30000        0.00000        0.20000
 PNT P00R    -0.30000       -0.30000        0.20000
 PNT P00S    -0.00000       -0.30000        0.20000
 PNT P00T    -0.30000        0.00000        0.60000
 PNT P00V    -0.30000       -0.30000        0.60000
 PNT P00W    -0.00000       -0.30000        0.60000
 PNT P00X    -0.00000        0.00000        0.60000
 PNT P00Z    -0.06000        0.00000        0.60000
 PNT P010    -0.00000       -0.06000        0.60000
 PNT P011    -0.06000       -0.06000        0.60000
 PNT P013    -0.00000        0.10000       -0.00000
 PNT P015    -0.07071        0.07071       -0.00000
 PNT P017    -0.00000        0.10000        0.20000
 PNT P01A    -0.07071        0.07071        0.20000
 PNT P01C    -0.05000        0.05000        0.27071
 PNT P01D    -0.00000        0.07071        0.27071
 PNT P01H    -0.00707        0.00707        0.29950
 PNT P01I    -0.00000        0.01000        0.29950
 PNT P01L    -0.30000        0.30000       -0.00000
 PNT P01M    -0.00000        0.30000       -0.00000
 PNT P01P    -0.30000        0.30000        0.20000
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 LINE L001 P001 P004 P003 104
 LINE L002 P004 P002 P003 104
 LINE L003 P005 P008 P007 104
 LINE L004 P008 P006 P007 104
 LINE L005 P009 P00A P00E 104
 LINE L006 P00A P00C P00E 104
 LINE L007 P00G P00I P00K 102
 LINE L008 P00I P00J P00K 102
 LINE L009 P00K P00G P007 102
 LINE L00A P00G P009 P007 104
 LINE L00C P009 P005 P007 104
 LINE L00E P00K P00J P007 102
 LINE L00G P00J P00C P007 104
 LINE L00I P00C P006 P007 104
 LINE L00J P00I P00A P007 104
 LINE L00K P00A P008 P007 104
 LINE L00L P00K P00E 104
 LINE L00N P00E P00C 104
 LINE L00O P00E P007 104
 LINE L00P P007 P006 104
 LINE L00R P006 P002 104
 LINE L00S P007 P003 104
 LINE L00T P003 P002 104
 LINE L00V P005 P001 104
 LINE L00W P008 P004 104
 LINE L00X P001 P00L 104
 LINE L00Z P00L P00N 104
 LINE L010 P00N P004 104
 LINE L011 P00N P00O 104
 LINE L012 P00O P002 104
 LINE L013 P006 P00S 104
 LINE L014 P00S P00R 104
 LINE L015 P00R P008 104
 LINE L016 P00N P00R 104
 LINE L017 P00R P00P 104
 LINE L019 P00P P005 104
 LINE L01A P009 P00T 104
 LINE L01B P00T P00V 104
 LINE L01C P00V P00A 104
 LINE L01D P00V P00W 104
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 GSUR A001 + BLEND - L00V + L003 + L00W - L001
 GSUR A002 + BLEND + L01J - L017 - L016 - L00Z
 GSUR A003 + BLEND - L00X - L00V - L019 - L01J
 GSUR A004 + BLEND + L019 + L003 - L015 + L017
 GSUR A005 + BLEND + L015 + L00W - L010 + L016
 GSUR A006 + BLEND + L010 - L001 + L00X + L00Z
 GSUR A007 + BLEND - L00W + L004 + L00R - L002
 GSUR A008 + BLEND + L016 - L014 + L01H - L011
 GSUR A009 + BLEND + L015 + L004 + L013 + L014
 GSUR A00A + BLEND - L013 + L00R - L012 - L01H
 GSUR A00C + BLEND + L012 - L002 - L010 + L011
 GSUR A00E + BLEND - L00C + L005 + L00K - L003
 GSUR A00G + BLEND + L01K + L01B + L01I + L017
 GSUR A00I + BLEND + L019 - L00C + L01A - L01K
 GSUR A00J + BLEND - L01A + L005 - L01C - L01B
 GSUR A00K + BLEND + L01C + L00K - L015 - L01I
 GSUR A00L + BLEND - L00K + L006 + L00I - L004
 GSUR A00N + BLEND - L01I + L01D + L01F + L014
 GSUR A00O + BLEND + L01C + L006 - L01E - L01D
 GSUR A00P + BLEND + L01E + L00I + L013 - L01F
 GSUR A00R + BLEND - L00A + L007 + L00J - L005
 GSUR A00S + BLEND + L01L + L01M + L01X - L01B
 GSUR A00T + BLEND - L01A - L00A + L01T - L01L
 GSUR A00V + BLEND - L01T + L007 + L01U - L01M
 GSUR A00W + BLEND - L01U + L00J - L01C - L01X
 GSUR A00X + BLEND + L008 + L00G - L006 - L00J
 GSUR A00Z + BLEND + L01N + L01P - L01D - L01X
 GSUR A010 + BLEND - L01U + L008 + L01V - L01N
 GSUR A011 + BLEND - L01V + L00G - L01E - L01P
 GSUR A012 + BLEND - L009 + L00E - L008 - L007
 GSUR A013 + BLEND + L01Q + L01R - L01N - L01M
 GSUR A014 + BLEND - L01T - L009 - L01S - L01Q
 GSUR A015 + BLEND + L01S + L00E + L01V - L01R
 GSUR A016 + BLEND - L00V + L022 + L02Q - L01Y
 GSUR A017 + BLEND + L01J - L032 - L031 - L02T
 GSUR A02E + BLEND - L00R - L00P + L00S + L00T
 GSUR A01A + BLEND + L019 + L022 - L030 + L032
 GSUR A01B + BLEND + L030 + L02Q - L02U + L031
 GSUR A01C + BLEND + L02U - L01Y + L00X + L02T
 GSUR A01D + BLEND - L02Q + L024 + L02M - L020
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 GBOD B001 NORM + A001 - A002 - A005 - A006 - A003 - A004
 GBOD B002 NORM + A007 - A008 - A00A - A00C + A005 - A009
 GBOD B003 NORM + A00E - A00G - A00K + A004 - A00I - A00J
 GBOD B004 NORM + A00L - A00N - A00P + A009 + A00K - A00O
 GBOD B005 NORM + A00R - A00S - A00W + A00J - A00T - A00V
 GBOD B006 NORM + A00X - A00Z + A00O + A00W - A010 - A011
 GBOD B007 NORM + A012 - A013 + A010 + A00V - A014 - A015
 GBOD B008 NORM - A016 + A017 + A01B + A01A + A003 + A01C
 GBOD B009 NORM - A01D + A01E + A01H + A01F - A01B + A01I
 GBOD B00A NORM - A01J + A01K + A01N + A01M + A00I - A01A
 GBOD B00C NORM - A01P + A01Q + A01S + A01R - A01N - A01F
 GBOD B00E NORM - A01T + A01U + A01Y + A01X + A00T - A01M
 GBOD B00G NORM - A020 + A022 - A01R + A026 + A024 - A01Y
 GBOD B00I NORM - A028 + A029 - A024 + A02D + A014 - A01X
 GBOD B00J NORM - A01S + A02Q + A031 + A030 + A02Z + A032
 GBOD B00K NORM - A01H + A02M + A034 + A033 - A031 + A036
 GBOD B00L NORM + A02T - A026 - A02Z - A03A - A037 - A039
 GBOD B00N NORM - A02D + A02V + A037 + A03C + A03B + A03E
 GBOD B00O NORM + A015 - A02B - A03G - A03H - A03B - A03F
 GBOD B00P NORM + A011 - A01V - A03J - A03K + A03G - A03I
 GBOD B00R NORM + A00P - A01L - A03N - A03O + A03J - A03M
 GBOD B00S NORM + A00A - A019 - A03R - A03S + A03N - A03P
 GBOD B00T NORM + A02E - A02L - A03V - A03W + A03P - A03U
 GBOD B00V NORM + A02F - A02O - A033 - A03Z + A03V - A03X
 GBOD B00W NORM - A02U + A02I - A030 + A041 + A040 + A03X
 GBOD B00X NORM + A02G - A02R - A040 + A03U + A03M - A043
 GBOD B00Z NORM + A02J - A02W + A043 + A03I + A03F - A044
 GBOD B010 NORM + A02K - A02Y - A041 + A044 - A03C + A039
 SETA uitgang s A019
 SETA uitgang s A01L
 SETA uitgang s A01V
 SETA uitgang s A02B
 SETA uitgang s A02L
 SETA uitgang s A02M
 SETA uitgang s A02O
 SETA uitgang s A02Q
 SETA uitgang s A02R
 SETA uitgang s A02T
 SETA uitgang s A02U
 SETA uitgang s A02V
 SETA uitgang s A02W
 SETA uitgang s A02Y
 SETA ingang s A002
 SETA ingang s A00G
 SETA ingang s A017
 SETA ingang s A01K
 SETA vloer s A006
 SETA vloer s A00C
 SETA vloer s A01C
 SETA vloer s A01I
 SETA vloer s A034
 SETA vloer s A03R
 SETA vloer s A03W
 SETA vloer s A03Z
 SETA tunnel s A008
 SETA tunnel s A00N
 SETA tunnel s A00S
 SETA tunnel s A00Z
 SETA tunnel s A013
 SETA tunnel s A01E
 SETA tunnel s A01Q
 SETA tunnel s A01U
 SETA tunnel s A022
 SETA tunnel s A029
 SETA tunnel s A032
 SETA tunnel s A036
 SETA tunnel s A03A
 SETA tunnel s A03E
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 ELTY lucht HE8
 COMP ingang do
 COMP uitgang do
 COMP tunnel do
 COMP vloer
 MESH lucht
 SEND all dolfyn INLE ingang OUTL uitgang SYMP tunnel WALL vloer WALL spiegel
 SEND ingang abq sur
 SEND uitgang abq sur
 SEND tunnel abq sur
 SEND vloer abq sur
 SEND spiegel abq sur
