 PNT P0  0.000000000000e+00  0.000000000000e+00  0.000000000000e+00
 PNT P1  0.000000000000e+00  0.000000000000e+00  4.800000000000e+01
 PNT P2  0.000000000000e+00  -4.093067600000e+01  6.708628100000e+01
 PNT P3  -1.955048247737e-07  1.690472700000e-01  4.836252200000e+01
 PNT P4  -3.323582177472e-06  -3.084084500000e+01  6.988428500000e+01
 PNT P5  -7.820192990948e-07  -1.418726100000e+01  5.638103100000e+01
 PNT P6  -9.548222124067e-07  -1.371741500000e+01  5.655204000000e+01
 PNT P7  -6.092148510106e-07  -1.465710800000e+01  5.621001800000e+01
 PNT P8  -6.092148510106e-07  -1.401625100000e+01  5.591118200000e+01
 PNT P9  -9.548222124067e-07  -1.435827200000e+01  5.685087600000e+01
 PNT Q1  -1.400355252201e-06  -1.177512300000e+01  5.665212200000e+01
 PNT Q2  0.000000000000e+00  -1.338899100000e+01  5.424338500000e+01
 PNT Q3  -1.746863517837e-06  -1.521019600000e+01  5.903616300000e+01
 PNT Q4  0.000000000000e+00  -1.689779500000e+01  5.587957000000e+01
 PNT PROT  1.000000000000e+02  -1.418724000000e+01  5.638107300000e+01
 PNT Q5  -6.000001000000e+00  -1.435827300000e+01  5.685087600000e+01
 PNT Q6  -6.000000500000e+00  -1.465710900000e+01  5.621001400000e+01
 PNT Q7  -6.000001000000e+00  -1.418726200000e+01  5.638102700000e+01
 PNT Q8  -6.000000000000e+00  -1.689779700000e+01  5.587956600000e+01
 PNT Q9  -6.000001400000e+00  -1.521019700000e+01  5.903616300000e+01
 PNT Q10  -6.000001000000e+00  -1.371741600000e+01  5.655203600000e+01
 PNT Q11  -6.000001400000e+00  -1.177512400000e+01  5.665212200000e+01
 PNT Q12  -6.000000500000e+00  -1.401625300000e+01  5.591117900000e+01
 PNT Q13  -6.000000000000e+00  -1.338899200000e+01  5.424338500000e+01
 PNT Q14  -6.000000000000e+00  1.690460100000e-01  4.836252200000e+01
 PNT Q15  -6.000000000000e+00  -1.239358310201e-06  4.799999600000e+01
 PNT Q16  -6.000000000000e+00  -4.093067600000e+01  6.708628100000e+01
 PNT Q17  -6.000003300000e+00  -3.084084500000e+01  6.988428500000e+01
 PNT PX  2.000000000000e+01  0.000000000000e+00  0.000000000000e+00
 PNT PZ  0.000000000000e+00  0.000000000000e+00  2.000000000000e+01
 PNT PY  0.000000000000e+00  2.000000000000e+01  0.000000000000e+00
 LINE U2 P2 P4 104
 LINE U4 P3 P1 104
 LINE U5 P7 P8 P5 104
 LINE U6 P9 P7 P5 104
 LINE U7 P8 P6 P5 104
 LINE U8 P6 P9 P5 104
 LINE U10 Q1 P3 -510
 LINE U11 P1 Q2 510
 LINE U13 P4 Q3 109
 LINE U14 Q3 Q1 104
 LINE U15 Q2 Q4 104
 LINE U16 Q4 P2 109
 LINE U17 Q3 Q4 104
 LINE U18 Q1 Q2 104
 LINE U19 P7 Q4 104
 LINE U20 P8 Q2 104
 LINE U21 P6 Q1 104
 LINE U22 P9 Q3 104
 LINE U23 P9 Q5 104
 LINE U24 P7 Q6 104
 LINE U25 Q5 Q6 Q7 104
 LINE U26 Q4 Q8 104
 LINE U27 Q6 Q8 104
 LINE U28 Q3 Q9 104
 LINE U29 Q9 Q8 104
 LINE U30 Q5 Q9 104
 LINE U31 P6 Q10 104
 LINE U32 Q10 Q5 Q7 104
 LINE U33 Q1 Q11 104
 LINE U34 Q9 Q11 104
 LINE U35 Q10 Q11 104
 LINE U36 P8 Q12 104
 LINE U37 Q12 Q10 Q7 104
 LINE U38 Q2 Q13 104
 LINE U39 Q11 Q13 104
 LINE U40 Q12 Q13 104
 LINE U41 Q6 Q12 Q7 104
 LINE U42 Q13 Q8 104
 LINE U43 P3 Q14 104
 LINE U44 P1 Q15 104
 LINE U45 Q14 Q15 104
 LINE U46 Q15 Q13 510
 LINE U47 Q11 Q14 -510
 LINE U48 P2 Q16 104
 LINE U49 P4 Q17 104
 LINE U50 Q16 Q17 104
 LINE U51 Q17 Q9 109
 LINE U52 Q8 Q16 109
 LCMB U1  + U11 + U15 + U16
 LCMB U3  + U13 + U14 + U10
 LCMB U9  + U13 + U14
 LCMB U12  + U15 + U16
 GSUR V1 + BLEND + U6 + U19 - U17 - U22
 GSUR V2 + BLEND + U8 + U22 + U14 - U21
 GSUR V3 + BLEND + U7 + U21 + U18 - U20
 GSUR V4 + BLEND + U5 + U20 + U15 - U19
 GSUR V5 + BLEND + U4 + U11 - U18 + U10
 GSUR V6 + BLEND + U2 + U13 + U17 + U16
 GSUR V7 + BLEND + U6 + U24 - U25 - U23
 GSUR V8 + BLEND + U19 + U26 - U27 - U24
 GSUR V9 + BLEND + U17 + U26 - U29 - U28
 GSUR V10 + BLEND + U22 + U28 - U30 - U23
 GSUR V11 + BLEND + U25 + U27 - U29 - U30
 GSUR V12 + BLEND + U8 + U23 - U32 - U31
 GSUR V13 + BLEND + U14 + U33 - U34 - U28
 GSUR V14 + BLEND + U21 + U33 - U35 - U31
 GSUR V15 + BLEND + U32 + U30 + U34 - U35
 GSUR V16 + BLEND + U7 + U31 - U37 - U36
 GSUR V17 + BLEND + U18 + U38 - U39 - U33
 GSUR V18 + BLEND + U20 + U38 - U40 - U36
 GSUR V19 + BLEND + U37 + U35 + U39 - U40
 GSUR V20 + BLEND + U5 + U36 - U41 - U24
 GSUR V21 + BLEND + U15 + U26 - U42 - U38
 GSUR V22 + BLEND + U41 + U40 + U42 - U27
 GSUR V23 + BLEND + U4 + U44 - U45 - U43
 GSUR V24 + BLEND + U11 + U38 - U46 - U44
 GSUR V25 + BLEND + U10 + U43 - U47 - U33
 GSUR V26 + BLEND + U45 + U46 - U39 + U47
 GSUR V27 + BLEND + U2 + U49 - U50 - U48
 GSUR V28 + BLEND + U13 + U28 - U51 - U49
 GSUR V29 + BLEND + U16 + U48 - U52 - U26
 GSUR V30 + BLEND + U50 + U51 + U29 + U52
 GBOD W1 NORM - V1 + V11 - V9 + V8 + V7 - V10
 GBOD W2 NORM - V2 + V15 + V13 + V10 + V12 - V14
 GBOD W3 NORM - V3 + V19 + V17 + V14 + V16 - V18
 GBOD W4 NORM - V4 + V22 + V21 + V18 + V20 - V8
 GBOD W5 NORM - V5 + V26 - V17 + V24 + V23 + V25
 GBOD W6 NORM - V6 + V30 + V9 + V28 + V27 + V29
 SETA KEIL p P1
 SETA KEIL p P2
 SETA KEIL p P3
 SETA KEIL p P4
 SETA KEIL p P5
 SETA KEIL p P6
 SETA KEIL p P7
 SETA KEIL p P8
 SETA KEIL p P9
 SETA KEIL p Q1
 SETA KEIL p Q2
 SETA KEIL p Q3
 SETA KEIL p Q4
 SETA KEIL p PROT
 SETA KEIL p Q5
 SETA KEIL p Q6
 SETA KEIL p Q7
 SETA KEIL p Q8
 SETA KEIL p Q9
 SETA KEIL p Q10
 SETA KEIL p Q11
 SETA KEIL p Q12
 SETA KEIL p Q13
 SETA KEIL p Q14
 SETA KEIL p Q15
 SETA KEIL p Q16
 SETA KEIL p Q17
 SETA KEIL l U2
 SETA KEIL l U4
 SETA KEIL l U5
 SETA KEIL l U6
 SETA KEIL l U7
 SETA KEIL l U8
 SETA KEIL l U10
 SETA KEIL l U11
 SETA KEIL l U13
 SETA KEIL l U14
 SETA KEIL l U15
 SETA KEIL l U16
 SETA KEIL l U17
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 plot p all b
 plus l all k
 plus s all m
 plus b all g
 plus la SPC k
