** m, kg, s
** dyn_visc=kin_visc*rho
** cp=R/(1-1/kappa)
**
*include, input=all.msh
*include, input=in.nam
*include, input=out.nam
** surfaces for drag calc
*include, input=profil.sur
*MATERIAL,NAME=AIR
*CONDUCTIVITY
0.025
*FLUID CONSTANTS
1004.85,1.786e-5,288.
*SPECIFIC GAS CONSTANT
287.1
*SOLID SECTION,ELSET=Eall,MATERIAL=AIR
*PHYSICAL CONSTANTS,ABSOLUTE ZERO=0.
*INITIAL CONDITIONS,TYPE=FLUID VELOCITY
Nall,1,248.
Nall,2,0.
Nall,3,0.
*INITIAL CONDITIONS,TYPE=PRESSURE
Nall,1.e5
*INITIAL CONDITIONS,TYPE=TEMPERATURE
Nall,288.
**
*STEP,INCF=500000
***CFD,STEADY STATE, COMPRESSIBLE
*CFD, COMPRESSIBLE
1.,1.
*BOUNDARYF
*include, input=in_11.bouf
*include, input=in_1.bouf
*include, input=in_2.bouf
*include, input=in_3.bouf
*include, input=out_8.bouf
** for viscous flow set this to:
***include, input=profil_1.bouf
***include, input=profil_2.bouf
*MASS FLOW
*include, input=s1.mfl
*include, input=s2.mfl
*include, input=wall.mfl
** for inviscid flow set this to:
*include, input=profil.mfl
*DFLUX
*include, input=profil.dfl
**
*NODE FILE,FREQUENCYF=1000,NSET=Nall
VF,PSF,PTF,TSF,TTF,MACH,CP
*EL FILE,FREQUENCYF=1000,ELSET=Eall
SF,SVF,HFLF
*FACE PRINT,SURFACE=Sprofil,FREQUENCYF=1000
DRAG
*END STEP
