 PNT D001  1.120000000000e-01  5.355390000000e+00  0.000000000000e+00
 PNT D002  3.930000000000e-01  5.391920000000e+00  0.000000000000e+00
 PNT D003  3.897700000000e-01  5.391630000000e+00  0.000000000000e+00
 PNT D004  3.862100000000e-01  5.391350000000e+00  0.000000000000e+00
 PNT D005  3.822900000000e-01  5.391100000000e+00  0.000000000000e+00
 PNT D006  3.780200000000e-01  5.390870000000e+00  0.000000000000e+00
 PNT D007  3.733300000000e-01  5.390700000000e+00  0.000000000000e+00
 PNT D008  3.682600000000e-01  5.390590000000e+00  0.000000000000e+00
 PNT D009  3.627100000000e-01  5.390540000000e+00  0.000000000000e+00
 PNT D00A  3.567500000000e-01  5.390590000000e+00  0.000000000000e+00
 PNT D00B  3.502800000000e-01  5.390700000000e+00  0.000000000000e+00
 PNT D00C  3.433600000000e-01  5.390900000000e+00  0.000000000000e+00
 PNT D00D  3.359200000000e-01  5.391210000000e+00  0.000000000000e+00
 PNT D00E  3.279900000000e-01  5.391620000000e+00  0.000000000000e+00
 PNT D00F  3.196000000000e-01  5.392130000000e+00  0.000000000000e+00
 PNT D00G  3.106500000000e-01  5.392760000000e+00  0.000000000000e+00
 PNT D00H  3.012400000000e-01  5.393500000000e+00  0.000000000000e+00
 PNT D00I  2.913900000000e-01  5.394340000000e+00  0.000000000000e+00
 PNT D00J  2.810300000000e-01  5.395270000000e+00  0.000000000000e+00
 PNT D00K  2.702400000000e-01  5.396290000000e+00  0.000000000000e+00
 PNT D00L  2.591600000000e-01  5.397360000000e+00  0.000000000000e+00
 PNT D00M  2.479900000000e-01  5.398420000000e+00  0.000000000000e+00
 PNT D00N  2.370900000000e-01  5.399450000000e+00  0.000000000000e+00
 PNT D00O  2.264900000000e-01  5.400410000000e+00  0.000000000000e+00
 PNT D00P  2.159400000000e-01  5.401280000000e+00  0.000000000000e+00
 PNT D00Q  2.056100000000e-01  5.402070000000e+00  0.000000000000e+00
 PNT D00R  1.951700000000e-01  5.402750000000e+00  0.000000000000e+00
 PNT D00S  1.843300000000e-01  5.403300000000e+00  0.000000000000e+00
 PNT D00T  1.725700000000e-01  5.403690000000e+00  0.000000000000e+00
 PNT D00U  1.599900000000e-01  5.403790000000e+00  0.000000000000e+00
 PNT D00V  1.471700000000e-01  5.403570000000e+00  0.000000000000e+00
 PNT D00W  1.344700000000e-01  5.403000000000e+00  0.000000000000e+00
 PNT D00X  1.220700000000e-01  5.402150000000e+00  0.000000000000e+00
 PNT D00Y  1.104200000000e-01  5.401100000000e+00  0.000000000000e+00
 PNT D00Z  9.926000000000e-02  5.399900000000e+00  0.000000000000e+00
 PNT D010  8.826000000000e-02  5.398560000000e+00  0.000000000000e+00
 PNT D011  7.788000000000e-02  5.397150000000e+00  0.000000000000e+00
 PNT D012  6.811000000000e-02  5.395680000000e+00  0.000000000000e+00
 PNT D013  5.926000000000e-02  5.394210000000e+00  0.000000000000e+00
 PNT D014  5.127000000000e-02  5.392760000000e+00  0.000000000000e+00
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 SEQA A001     pnt  D05E D052 D051 D05I
 SEQA A002     pnt  D05J D059 D05A D05F
 SEQA A003     pnt  D001 D03R D03Q D03P D03O D03N D03M D03L D03K D03J
 SEQA A003 END pnt  D03I D03H
 SEQA A004     pnt  D05H D05D D05C D05B D05P
 SEQA A005     pnt  D04X D00Z D010 D011 D012 D013 D014 D015 D016 D017
 SEQA A005 END pnt  D018 D019
 SEQA A006     pnt  D05I D050 D04Z D056 D05L
 SEQA A007     pnt  D03H D03G D03F D03E D03D D03C D03B D03A D039 D038
 SEQA A007 END pnt  D037 D036 D035 D034 D033 D032 D031 D030 D02Z D02Y
 SEQA A007 END pnt  D02X D02W D02V D02U D02T D02S D02R D02Q D02P D02O
 SEQA A007 END pnt  D02N D02M D02L D02K D02J D02I D02H D02G D02F D02E
 SEQA A007 END pnt  D02D D02C D02B D02A D029 D028 D027 D026 D025 D024
 SEQA A007 END pnt  D023 D022 D05K
 SEQA A008     pnt  D05K D021 D020 D01Z D01Y D01X D01W D01V D01U D01T
 SEQA A008 END pnt  D01S D01R D01Q D01P D01O D01N D01M D01L D01K D01J
 SEQA A008 END pnt  D01I D01H D01G D01F D01E D01D D01C D01B D01A D019
 SEQA A009     pnt  D05L D057 D058 D05J
 SEQA A00A     pnt  D04Y D04W D04V D04U D04T D04S D04R D04Q D04P D04O
 SEQA A00A END pnt  D04N D04M D04L D04K D04J D04I D04H D05M
 SEQA A00B     pnt  D05E D053 D05S
 SEQA A00C     pnt  D05N D055 D05G
 SEQA A00D     pnt  D04Y D002 D003 D004 D005 D006 D007 D008 D009 D00A
 SEQA A00D END pnt  D00B D00C D00D D00E D00F D00G D00H D00I D00J D00K
 SEQA A00D END pnt  D00L D00M D00N D00O D00P D00Q D00R D05O
 SEQA A00E     pnt  D05O D00S D00T D00U D00V D00W D00X D00Y D04X
 SEQA A00F     pnt  D05P D05Q D05F
 SEQA A00G     pnt  D05M D04G D04F D04E D04D D04C D04B D04A D049 D048
 SEQA A00G END pnt  D047 D046 D045 D05R
 SEQA A00H     pnt  D05R D044 D043 D042 D041 D040 D03Z D03Y D03X D03W
 SEQA A00H END pnt  D03V D03U D03T D03S D001
 SEQA A00I     pnt  D05S D054 D05N
 LINE L002 D04Y D05G 299050
 LINE L003 P003 P002 120
 LINE L004 P002 P005 120
 LINE L007 P005 P004 120
 LINE L005 D05H D04Y -299050
 LINE L006 D05E D05I A001 120
 LINE L008 D05J D05F A002 320
 LINE L009 D001 D05E 999050
 LINE L00A D04X D05F 999050
 LINE L00B D001 D03H A003 120
 LINE L00C D05H D05P A004 -460
 LINE L00D D04X D019 A005 -320
 LINE L00E D05I D05L A006 -528
 LINE L00F D03H D05K A007 -30028
 LINE L00G D05K D019 A008 30028
 LINE L00H D05L D05J A009 528
 LINE L00I D04Y D05M A00A 116
 LINE L00J D05E D05S A00B -440
 LINE L00K D05N D05G A00C 116
 LINE L00L D04Y D05O A00D -460
 LINE L00M D05O D04X A00E 520
 LINE L00N D05P D05F A00F 520
 LINE L00O D05M D05R A00G -434
 LINE L00P D05R D001 A00H 440
 LINE L00Q D05S D05N A00I 434
 LINE L00U D05I P005 100030
 LINE L00V D05J P002 100030
 LINE L00W D060 D061 -250
 LINE L00X D061 D05Z 250
 LINE L00Y D05G D05Z 80025
 LINE L00Z D05H D060 80025
 LINE L010 D04Y D061 80025
 LINE L011 D05Z P004 820
 LINE L012 P003 D060 -820
 LCMB C001  + L006 + L00E + L00H + L008
 LCMB C002  + L00D - L00G - L00F - L00B
 LCMB C003  + L00I + L00O + L00P
 LCMB C004  + L00J + L00Q + L00K
 LCMB C005  + L00L + L00M
 LCMB C006  + L00C + L00N
 SHPE H001 PLN P005 P002 P003
 GSUR A001 + BLEND + L009 + C001 - L00A + C002
 GSUR A002 + BLEND - C003 + L002 - C004 - L009
 GSUR A003 + BLEND - C006 + L005 + C005 + L00A
 GSUR A004 + BLEND - L005 + L00Z + L00W - L010
 GSUR A005 + H001 - L004 - L00V - L00H - L00E + L00U
 GSUR A006 + BLEND + L010 + L00X - L00Y - L002
 GSUR A009 + H001 + L00V - L003 + L012 - L00Z + L00C + L00N - L008
 GSUR A008 + H001 - L00U - L006 + L00J + L00Q + L00K + L00Y + L011 - L007
 SETA profil p D001
 SETA profil p D002
 SETA profil p D003
 SETA profil p D004
 SETA profil p D005
 SETA profil p D006
 SETA profil p D007
 SETA profil p D008
 SETA profil p D009
 SETA profil p D00A
 SETA profil p D00B
 SETA profil p D00C
 SETA profil p D00D
 SETA profil p D00E
 SETA profil p D00F
 SETA profil p D00G
 SETA profil p D00H
 SETA profil p D00I
 SETA profil p D00J
 SETA profil p D00K
 SETA profil p D00L
 SETA profil p D00M
 SETA profil p D00N
 SETA profil p D00O
 SETA profil p D00P
 SETA profil p D00Q
 SETA profil p D00R
 SETA profil p D00S
 SETA profil p D00T
 SETA profil p D00U
 SETA profil p D00V
 SETA profil p D00W
 SETA profil p D00X
 SETA profil p D00Y
 SETA profil p D00Z
 SETA profil p D010
 SETA profil p D011
 SETA profil p D012
 SETA profil p D013
 SETA profil p D014
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 ELTY tr3u TR3U 1
 ELTY qu4f QU4
 plot p all b
 plus l all k
 plus s all m
 plus b all g
 plus la out k
 plus la in g
 plus la wall b
