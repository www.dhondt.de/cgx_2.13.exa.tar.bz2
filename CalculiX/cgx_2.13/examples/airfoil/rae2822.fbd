 PNT P088     0.11200       -5.35539        0.00000
 PNT P01F     0.39300       -5.39192        0.00000
 PNT P01H     0.38977       -5.39163        0.00000
 PNT P01I     0.38621       -5.39135        0.00000
 PNT P01J     0.38229       -5.39110        0.00000
 PNT P01K     0.37802       -5.39087        0.00000
 PNT P01L     0.37333       -5.39070        0.00000
 PNT P01M     0.36826       -5.39059        0.00000
 PNT P01N     0.36271       -5.39054        0.00000
 PNT P01P     0.35675       -5.39059        0.00000
 PNT P01Q     0.35028       -5.39070        0.00000
 PNT P01R     0.34336       -5.39090        0.00000
 PNT P01S     0.33592       -5.39121        0.00000
 PNT P01T     0.32799       -5.39162        0.00000
 PNT P01U     0.31960       -5.39213        0.00000
 PNT P01V     0.31065       -5.39276        0.00000
 PNT P01X     0.30124       -5.39350        0.00000
 PNT P01Y     0.29139       -5.39434        0.00000
 PNT P020     0.28103       -5.39527        0.00000
 PNT P022     0.27024       -5.39629        0.00000
 PNT P024     0.25916       -5.39736        0.00000
 PNT P026     0.24799       -5.39842        0.00000
 PNT P028     0.23709       -5.39945        0.00000
 PNT P029     0.22649       -5.40041        0.00000
 PNT P02B     0.21594       -5.40128        0.00000
 PNT P02D     0.20561       -5.40207        0.00000
 PNT P02E     0.19517       -5.40275        0.00000
 PNT P02F     0.18433       -5.40330        0.00000
 PNT P02G     0.17257       -5.40369        0.00000
 PNT P02I     0.15999       -5.40379        0.00000
 PNT P02J     0.14717       -5.40357        0.00000
 PNT P02K     0.13447       -5.40300        0.00000
 PNT P02L     0.12207       -5.40215        0.00000
 PNT P02M     0.11042       -5.40110        0.00000
 PNT P02O     0.09926       -5.39990        0.00000
 PNT P02Q     0.08826       -5.39856        0.00000
 PNT P02R     0.07788       -5.39715        0.00000
 PNT P02T     0.06811       -5.39568        0.00000
 PNT P02U     0.05926       -5.39421        0.00000
 PNT P02V     0.05127       -5.39276        0.00000
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 SEQA S005     pnt  P010 P00C P00A P01C
 SEQA S006     pnt  P01D P00R P00S P011
 SEQA S00K     pnt  P00O P00K P08B
 SEQA S00V     pnt  P08M P08N P011
 SEQA S00A     pnt  P088 P06H P06F P06D P06C P06B P069 P068 P066 P064
 SEQA S00A END pnt  P062 P060
 SEQA S00E     pnt  P089 P02O P02Q P02R P02T P02U P02V P02W P02Y P02Z
 SEQA S00E END pnt  P030 P031
 SEQA S00P     pnt  P01C P008 P006 P00L P08H
 SEQA S00N     pnt  P060 P05Z P05Y P05W P05V P05T P05S P05R P05P P05N
 SEQA S00N END pnt  P05M P05L P05J P05I P05H P05G P05F P05D P05C P05A
 SEQA S00N END pnt  P059 P058 P056 P054 P052 P050 P04Z P04X P04W P04V
 SEQA S00N END pnt  P04T P04R P04Q P04P P04N P04M P04L P04J P04I P04H
 SEQA S00N END pnt  P04G P04E P04D P04C P04B P049 P048 P046 P045 P044
 SEQA S00N END pnt  P043 P041 P08G
 SEQA S00J     pnt  P08A P009 P007
 SEQA S00L     pnt  P08B P00E P08A
 SEQA S00O     pnt  P08G P040 P03Z P03X P03W P03V P03U P03S P03R P03P
 SEQA S00O END pnt  P03O P03N P03M P03K P03J P03I P03H P03G P03F P03E
 SEQA S00O END pnt  P03C P03B P03A P039 P037 P036 P034 P033 P032 P031
 SEQA S00R     pnt  P08H P00N P00P P01D
 SEQA S001     pnt  P007 P01E P010
 SEQA S004     pnt  P011 P085 P00O
 SEQA S007     pnt  P001 P083 P082 P081 P080 P07Y P07W P07V P07U P07S
 SEQA S007 END pnt  P07R P07Q P07P P07O P07M P07L P07J P08I
 SEQA S00G     pnt  P08J P00J P012
 SEQA S00S     pnt  P013 P00X P00W P00V P08M
 SEQA S002     pnt  P001 P01F P01H P01I P01J P01K P01L P01M P01N P01P
 SEQA S002 END pnt  P01Q P01R P01S P01T P01U P01V P01X P01Y P020 P022
 SEQA S002 END pnt  P024 P026 P028 P029 P02B P02D P02E P08K
 SEQA S00I     pnt  P08K P02F P02G P02I P02J P02K P02L P02M P089
 SEQA S00T     pnt  P08M P011
 SEQA S00W     pnt  P010 P00G P08P
 SEQA S003     pnt  P08I P07I P07H P07F P07D P07B P079 P078 P076 P075
 SEQA S003 END pnt  P074 P072 P070 P08O
 SEQA S00C     pnt  P08O P06Z P06Y P06W P06V P06U P06S P06R P06P P06N
 SEQA S00C END pnt  P06M P06L P06J P06I P088
 SEQA S00X     pnt  P08P P00I P08J
 SEQA S008     pnt  P007 P08S P00T
 SEQA S009     pnt  P00O P08T P00Z
 SEQA S00Z     pnt  P007 P08U P08F
 SEQA S010     pnt  P08D P08W P00O
 LINE L01S P005 P08F -40012
 LINE L002 P003 P016 -512
 LINE L003 P016 P01A -620
 LINE L022 P00O P08R 812
 LINE L005 P001 P012 299050
 LINE L006 P013 P001 -299050
 LINE L007 P01A P01B -250
 LINE L00A P01B P019 250
 LINE L008 P014 P08Q 190
 LINE L00G P007 P010 S001 -30020
 LINE L00I P011 P00O S004 20020
 LINE L00E P08Q P005 10010
 LINE L01N P00O P08B S00K 230
 LINE L00L P007 P00T S008 190
 LINE L00N P00O P00Z S009 180
 LINE L00O P00Z P013 -40020
 LINE L00P P012 P00T 40020
 LINE L00R P004 P014 -80025
 LINE L00K P08Q P007 -812
 LINE L00T P015 P003 80025
 LINE L00V P012 P019 80025
 LINE L00W P017 P004 512
 LINE L00X P019 P017 620
 LINE L00Z P013 P01A 80025
 LINE L010 P001 P01B 80025
 LINE L011 P017 P00T -80025
 LINE L012 P00T P014 512
 LINE L013 P016 P00Z -80025
 LINE L014 P00Z P015 512
 LINE L015 P010 P01C S005 120
 LINE L016 P01D P011 S006 320
 LINE L017 P086 P087 80025
 LINE L01F P088 P010 999050
 LINE L01J P089 P011 999050
 LINE L01E P088 P060 S00A 120
 LINE L01B P013 P08M S00S -460
 LINE L01I P089 P031 S00E -320
 LINE L01X P01C P08H S00P -528
 LINE L01U P060 P08G S00N -30028
 LINE L01M P08A P007 S00J -430
 LINE L01P P08B P08A S00L 136
 LINE L01R P08D P002 40012
 LINE L01V P08G P031 S00O 30028
 LINE L01Y P08H P01D S00R 528
 LINE L001 P001 P08I S007 116
 LINE L01H P010 P08P S00W -440
 LINE L019 P08J P012 S00G 116
 LINE L009 P001 P08K S002 -460
 LINE L01A P08K P089 S00I 520
 LINE L01C P08M P011 S00V 520
 LINE L00C P08I P08O S003 -434
 LINE L01D P08O P088 S00C 440
 LINE L01K P08P P08J S00X 434
 LINE L00S P007 P08F S00Z 610
 LINE L01L P08D P00O S010 -610
 LINE L01Q P002 P08R -10010
 LINE L020 P08R P015 180
 LINE L004 P08F P08Y -848
 LINE L00J P08Y P08D 848
 LCMB C001  + L015 + L01X + L01Y + L016
 LCMB C002  + L01N + L01P + L01M
 LCMB C003  + L01S + L004 + L00J + L01R
 LCMB C004  + L01U + L01V
 LCMB C005  + L01X + L01Y
 LCMB C006  + L01I - L01V - L01U - L01E
 LCMB C007  + L001 + L00C + L01D
 LCMB C008  + L01H + L01K + L019
 LCMB C009  + L009 + L01A
 LCMB C00A  + L01B + L01C
 LCMB C00C  + L004 + L00J
 GSUR A001 + BLEND - L006 + L00Z + L007 - L010
 GSUR A002 + BLEND + L010 + L00A - L00V - L005
 GSUR A003 + BLEND - L00G - C002 - L00I - C001
 GSUR A004 + BLEND + C00C + L01L + C002 + L00S
 GSUR A005 + BLEND + L01R + L01Q - L022 - L01L
 GSUR A006 + BLEND + L014 + L00T + L002 + L013
 GSUR A007 + BLEND + L01S - L00S - L00K + L00E
 GSUR A008 + BLEND - L012 - L011 + L00W + L00R
 GSUR A009 + BLEND + L00G + C008 + L00P - L00L
 GSUR A00A + BLEND + L00I + L00N + L00O + C00A
 GSUR A00C + BLEND - L00P + L00V + L00X + L011
 GSUR A00E + BLEND - L00O - L013 + L003 - L00Z
 GSUR A00G + BLEND + L01F + C001 - L01J + C006
 GSUR A00K + BLEND - C007 + L005 - C008 - L01F
 GSUR A00L + BLEND - C00A + L006 + C009 + L01J
 GSUR A00I + BLEND + L00K + L00L + L012 + L008
 GSUR A00J + BLEND + L022 + L020 - L014 - L00N
 SETA profil p P088
 SETA profil p P01F
 SETA profil p P01H
 SETA profil p P01I
 SETA profil p P01J
 SETA profil p P01K
 SETA profil p P01L
 SETA profil p P01M
 SETA profil p P01N
 SETA profil p P01P
 SETA profil p P01Q
 SETA profil p P01R
 SETA profil p P01S
 SETA profil p P01T
 SETA profil p P01U
 SETA profil p P01V
 SETA profil p P01X
 SETA profil p P01Y
 SETA profil p P020
 SETA profil p P022
 SETA profil p P024
 SETA profil p P026
 SETA profil p P028
 SETA profil p P029
 SETA profil p P02B
 SETA profil p P02D
 SETA profil p P02E
 SETA profil p P02F
 SETA profil p P02G
 SETA profil p P02I
 SETA profil p P02J
 SETA profil p P02K
 SETA profil p P02L
 SETA profil p P02M
 SETA profil p P02O
 SETA profil p P02Q
 SETA profil p P02R
 SETA profil p P02T
 SETA profil p P02U
 SETA profil p P02V
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 ELTY all QU4
 plot p all b
 plus l all k
 plus s all m
 plus b all g
 plus la l k
