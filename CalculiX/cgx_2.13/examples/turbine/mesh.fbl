del me
#div all div 2
elty all
elty all te10
mesh all
merg n all 0.02
