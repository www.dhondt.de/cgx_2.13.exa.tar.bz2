 PNT P1      -0.02870        2.40120       28.15880
 PNT P2       0.00001        4.30220       40.34120
 PNT P3      13.98710        0.85058       40.42490
 PNT P4      21.99990        7.49557       35.52520
 PNT P5      27.06742        4.88009       19.06155
 PNT P6      27.09140        1.34995       12.48357
 PNT P7      14.00420       -2.96068       14.21896
 PNT P8       4.24200       -1.50770       20.98230
 PNT P11      0.66250        1.24841       28.11380
 PNT Q1       0.63534        2.94966       40.46316
 PNT Q2      15.78270        1.79820       38.53260
 PNT Q3       3.15740        1.63613       40.53740
 PNT Q4       5.12370        0.54452       40.56700
 PNT Q5       7.33920       -0.23770       40.57120
 PNT Q6       9.96100       -0.49360       40.56690
 PNT Q7      12.20820        0.00399       40.59420
 PNT Q8      14.84330        1.28130       39.51350
 PNT Q9      17.24908        2.78339       37.42750
 PNT Q10     19.05929        4.29833       36.52250
 PNT Q11      2.07280        0.08069       25.28729
 PNT Q12      6.73680       -2.49397       17.49446
 PNT Q13      9.70160       -3.20418       15.24237
 PNT Q14     20.69299       -1.35091       13.44318
 PNT Q15     23.44080       -0.26508       13.06042
 PNT Q16     17.47520       -2.32870       13.79435
 PNT Q17      8.78604       -0.74237       34.06115
 PNT Q18      5.92935       -0.19756       32.47051
 PNT Q19      3.19028        0.68437       29.90936
 PNT Q20     10.84765       -0.66904       35.40834
 PNT Q21     13.43935        0.17659       36.94702
 PNT Q22     24.60276        6.83979       27.74372
 PNT Q23      7.28384       -0.77288       29.88752
 PNT Q24     12.11716       -0.54413       34.05553
 PNT Q25      9.31617       -1.33364       26.95230
 PNT Q26     13.49098       -0.25025       32.88145
 PNT Q27     11.64284       -1.55986       24.72154
 PNT Q28     13.61607       -1.46795       23.13652
 PNT Q29     16.08994       -0.95153       21.96243
 PNT Q30     18.79942       -0.04061       20.96446
 PNT Q31     21.39121        1.12947       20.20130
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 SEQA A00K     pnt  Q165 Q169 Q170 Q168
 SEQA A00L     pnt  Q87 Q46 Q47 Q88
 SEQA S1     pnt  PS1 PS2 PS3 PS4 PS5
 SEQA S2     pnt  PS6 PS7 PS8 PS9 PS10
 SEQA S7     pnt  PS1 PS12 PS6
 SEQA S5     pnt  PS5 PS11 PS10
 SEQA S3     pnt  PD1 PD2 PD3 PD4 PD5
 SEQA S4     pnt  PD6 PD7 PD8 PD9 PD10
 SEQA S8     pnt  PD1 PD12 PD6
 SEQA S6     pnt  PD5 PD11 PD10
 SEQA S004     pnt  P008 P00G Q191
 SEQA S005     pnt  P006 P00I Q189
 SEQA S002     pnt  Q190 P00C P007
 SEQA S003     pnt  P009 P00E Q192
 SEQA S006     pnt  Q87 P00S P00K
 SEQA S007     pnt  Q122 P00T P00O
 SEQA S001     pnt  Q165 P00R P00P
 SEQA A001     pnt  D00H D00W D00V
 SEQA A002     pnt  Q166 Q176 Q175 Q174 Q173 Q172 Q171
 SEQA A003     pnt  Q12 Q13 P7 Q16 Q14 Q15 P6
 SEQA A004     pnt  Q111 Q120 Q119 Q118 Q117 Q116 Q114
 SEQA A005     pnt  D008 D00F D00E D00D D00C D00B D00A
 SEQA A006     pnt  Q164 Q167 Q166
 SEQA A007     pnt  Q11 P8 Q12
 SEQA A008     pnt  Q109 Q113 Q111
 SEQA A009     pnt  D007 D009 D008
 SEQA A00A     pnt  Q1 Q44 P11
 SEQA A00B     pnt  Q103 Q107 Q106
 SEQA A00C     pnt  Q27 Q28 Q29 Q30 Q31 Q32 P5
 SEQA A00D     pnt  Q76 Q98 Q99 Q100 Q101 Q102 Q96
 SEQA A00E     pnt  Q23 Q25 Q27
 SEQA A00F     pnt  Q71 Q78 Q76
 SEQA A00G     pnt  Q33 Q34 Q35 Q36 Q37 Q38 Q22
 SEQA A00H     pnt  Q73 Q84 Q85 Q86 Q90 Q91 Q82
 SEQA A00I     pnt  Q40 Q10 Q41 P4
 SEQA A00J     pnt  Q79 Q94 Q95 Q92
 SEQA A00M     pnt  Q122 Q124 Q125 Q123
 SEQA A00N     pnt  D00H D00J D00K D00I
 SEQA A00O     pnt  Q24 Q26 Q33
 SEQA A00P     pnt  Q69 Q75 Q73
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 LINE L9 P11 P1 104
 LINE U1 P2 Q1 104
 LINE U26 Q11 P11 102
 LINE U53 Q18 Q23 102
 LINE U55 Q20 Q24 102
 LINE L00F Q4 Q18 A00Q 116
 LINE L00H Q60 Q63 A00R 116
 LINE U234 Q88 P6 112
 LINE U235 P1 Q89 102
 LINE U236 Q89 Q87 108
 LINE U237 Q89 Q11 104
 LINE U238 Q87 Q12 112
 LINE U761 Q316 Q317 212
 LINE U8 Q2 Q39 102
 LINE U62 P1 Q45 108
 LINE U64 Q45 P2 108
 LINE U91 Q6 Q48 Q49 104
 LINE U92 P3 Q50 Q51 104
 LINE U96 Q20 Q53 Q54 104
 LINE U100 Q2 Q56 Q57 104
 LINE U107 Q4 Q60 Q61 104
 LINE U111 Q18 Q63 Q64 104
 LINE U118 Q39 Q67 Q68 104
 LINE U119 Q56 Q67 102
 LINE U120 Q24 Q69 Q70 104
 LINE U121 Q53 Q69 102
 LINE U123 Q23 Q71 Q72 104
 LINE U124 Q63 Q71 102
 LINE U126 Q33 Q73 Q74 104
 LINE L00I Q6 Q20 A00S 104
 LINE L00M Q48 Q53 A00T 104
 LINE U130 Q27 Q76 Q77 104
 LINE U135 Q40 Q79 Q80 104
 LINE U140 Q22 Q82 Q83 104
 LINE U148 P4 Q92 Q93 104
 LINE U154 P5 Q96 Q97 104
 LINE U163 Q1 Q103 A01N 104
 LINE U167 P11 Q106 A01M 104
 LINE U174 Q11 Q109 A01L 104
 LINE U175 Q109 Q106 102
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 LCMB L1  + U62 + U64
 LCMB L5  - L044 - L02U
 LCMB U6  + L03G
 LCMB U47  + L03V
 LCMB U48  + L03U
 LCMB U49  + L00F
 LCMB U51  + L00I
 LCMB U233  + L03R
 LCMB U2  + L036 + L040
 LCMB U3  + L02A
 LCMB U5  + L037 + L042
 LCMB U7  + L02H
 LCMB U27  + L02B
 LCMB U31  + L02K
 LCMB U32  + L017
 LCMB U37  + L026
 LCMB U38  + L01D
 LCMB U40  + L00Y
 LCMB U43  + L023
 LCMB U76  + L009
 LCMB U78  + L03K
 LCMB U80  + L01W
 LCMB U82  + L03M
 LCMB U85  + L03O
 LCMB U86  + L03I
 LCMB U87  - L00Q - L031
 LCMB U88  - L03Y - L033
 LCMB U89  + L03D
 LCMB U90  + L039
 LCMB U95  + L01B
 LCMB U99  + L00M
 LCMB U103  + L029
 LCMB U106  + L01C
 LCMB U110  + L014
 LCMB U114  + L00H
 LCMB U117  + L028
 LCMB U122  + L02G
 LCMB U125  + L02C
 LCMB U129  + L00A
 LCMB U133  + L03L
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 GSUR V1 + BLEND - U32 + U51 + U37 - U38
 GSUR V2 + BLEND - U40 + U49 + U43 - U51
 GSUR V3 + BLEND - U8 - U37 + U55 + U27
 GSUR V4 + BLEND - U55 - U43 + U53 + U3
 GSUR V5 + BLEND - U76 - U3 + U78 + U7
 GSUR V6 + BLEND - U80 - U27 + U76 + U31
 GSUR V7 + BLEND - U31 + U82 + U47 - U85
 GSUR V8 + BLEND - U7 + U86 + U48 - U82
 GSUR V9 + BLEND + U87 + U6 - U88 - U49
 GSUR V10 + BLEND - U53 + U88 - U26 + U2
 GSUR V11 + BLEND - U78 - U2 + U89 + U5
 GSUR V12 + BLEND - U5 + U90 - L5 - U86
 GSUR V13 + BLEND - U237 + U236 + U238 - U89
 GSUR V14 + BLEND - U238 + U233 + U234 - U90
 GSUR A016 + BLEND + U376 - U375 + U367 + L02M - L01Q
 GSUR V16 + BLEND - U1 - L1 - L9 - U6
 GSUR V17 + BLEND + L9 + U235 + U237 + U26
 GSUR V18 + BLEND + U32 + U92 - U95 - U91
 GSUR V19 + BLEND + U51 + U96 - U99 - U91
 GSUR V20 + BLEND - U37 + U96 + U103 - U100
 GSUR V21 + BLEND + U38 + U100 - U106 - U92
 GSUR V22 + BLEND - U95 + U99 + U103 - U106
 GSUR V23 + BLEND + U40 + U91 - U110 - U107
 GSUR V24 + BLEND + U49 + U111 - U114 - U107
 GSUR V25 + BLEND - U43 + U111 + U117 - U96
 GSUR V26 + BLEND - U110 + U114 + U117 - U99
 GSUR V27 + BLEND + U8 + U118 - U119 - U100
 GSUR V28 + BLEND + U55 + U120 - U121 - U96
 GSUR V29 + BLEND + U27 + U118 - U122 - U120
 GSUR V30 + BLEND - U119 - U103 + U121 + U122
 GSUR V31 + BLEND + U53 + U123 - U124 - U111
 GSUR V32 + BLEND + U3 + U120 - U125 - U123
 GSUR V33 + BLEND - U121 - U117 + U124 + U125
 GSUR V34 + BLEND + U76 + U126 - U129 - U120
 GSUR V35 + BLEND + U78 + U130 - U133 - U123
 GSUR V36 + BLEND + U7 + U126 - U134 - U130
 GSUR V37 + BLEND - U129 - U125 + U133 + U134
 GSUR V38 + BLEND + U80 + U135 - U138 - U118
 GSUR V39 + BLEND + U31 + U135 - U139 - U126
 GSUR V40 + BLEND - U138 - U122 + U129 + U139
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 GBOD W1 NORM + V1 - V22 + V20 + V21 + V18 - V19
 GBOD W2 NORM + V2 - V26 + V25 + V19 + V23 - V24
 GBOD W3 NORM + V3 - V30 - V28 - V29 + V27 - V20
 GBOD W4 NORM + V4 - V33 - V31 - V32 + V28 - V25
 GBOD W5 NORM + V5 - V37 - V35 - V36 + V34 + V32
 GBOD W6 NORM + V6 - V40 - V34 - V39 + V38 + V29
 GBOD W7 NORM + V7 - V44 + V42 + V43 + V39 - V41
 GBOD W8 NORM + V8 - V47 + V46 + V41 + V36 - V45
 GBOD W9 NORM + V9 - V51 + V50 + V24 + V48 + V49
 GBOD W10 NORM + V10 - V54 + V52 - V53 + V31 - V50
 GBOD W11 NORM + V11 - V57 + V55 - V56 + V35 + V53
 GBOD W12 NORM + V12 - V60 + V59 + V45 + V56 + V58
 GBOD W13 NORM + V13 - V64 - V63 - V55 + V61 - V62
 GBOD W14 NORM + V14 - V67 - V66 - V58 + V63 - V65
 GBOD B001 NORM - A002 + A016 - V173 + V176 - V177 + A00U - A020
 GBOD W16 NORM + V16 - V74 + V73 - V49 + V71 + V72
 GBOD W17 NORM + V17 - V76 - V61 - V52 - V73 - V75
 GBOD W18 NORM - V13 + V139 + V137 + V136 - V135 + V138
 GBOD W19 NORM - V14 + V143 + V141 + V140 - V137 + V142
 GBOD B002 NORM - A016 + A018 - V161 + V168 - V170 + A00Q - A01V
 GBOD B006 NORM + V150 + A00K - A00O - A00P + A009 - A00N
 GBOD B004 NORM + VV1 - A005 - A009 - A00A - A007 - A008
 GBOD W24 NORM + V66 - V162 + V160 + V161 - V158 - V159
 GBOD B003 NORM - A018 + A019 + A01D + A01C + A01B + A01F + A01E
 GBOD W26 NORM - V141 + V169 - V167 + V166 + V158 - V168
 GBOD B005 NORM - V16 + A006 + A00G + A00E + A00C + A00I
 GBOD B007 NORM - V17 + A00L + A00S + A00R - A00G + A00T
 GBOD B008 NORM + A00O - A00S - A00W - A00X - A00V + V135
 GBOD B009 NORM - A019 + A01A - A010 + A012 + A013 - A00Y + A025
 GBOD B00A NORM + V64 - A00B + A01I + A027 - A01G + A01H
 GBOD B00B NORM + V67 - A00D + A01M + A028 - A01I + A029
 GBOD B00D NORM + V74 - A00H - A01S + A026 - A01P - A02A
 GBOD B00E NORM + V76 - A00J + A01G + A017 + A01S + A01T
 GBOD B00F NORM - V160 + A00M + A01W - A01U - A01M + A01V
 SETA CYC1 p Q316
 SETA CYC1 p Q317
 SETA CYC1 p Q163
 SETA CYC1 p Q164
 SETA CYC1 p Q165
 SETA CYC1 p Q166
 SETA CYC1 p Q167
 SETA CYC1 p Q168
 SETA CYC1 p Q169
 SETA CYC1 p Q170
 SETA CYC1 p Q171
 SETA CYC1 p Q172
 SETA CYC1 p Q173
 SETA CYC1 p Q174
 SETA CYC1 p Q175
 SETA CYC1 p Q176
 SETA CYC1 p Q177
 SETA CYC1 p Q178
 SETA CYC1 p Q185
 SETA CYC1 p Q186
 SETA CYC1 p Q187
 SETA CYC1 p Q188
 SETA CYC1 p Q244
 SETA CYC1 p Q245
 SETA CYC1 p Q246
 SETA CYC1 p Q247
 SETA CYC1 p Q251
 SETA CYC1 p P00L
 SETA CYC1 p P00P
 SETA CYC1 p P00R
 SETA CYC1 l U761
 SETA CYC1 l L03Q
 SETA CYC1 l U258
 SETA CYC1 l U260
 SETA CYC1 l U262
 SETA CYC1 l U272
 SETA CYC1 l U280
 SETA CYC1 l U281
 SETA CYC1 l U284
 SETA CYC1 l U285
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 ELTY all HE20R
 plot b all g
 plus si b m
 plus sa SSI g
 plus si SSI g
 plus si SFS b
