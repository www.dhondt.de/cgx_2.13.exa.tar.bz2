 PNT P3     -32.00000       -4.99286        9.22841
 PNT P6      -8.01259       18.60543       39.20786
 PNT P7     -25.97490       -3.20194       30.02973
 PNT P8     -31.44650      -11.19022       28.05031
 PNT Q1     -10.20380       13.34365       36.16946
 PNT Q4     -13.93220        9.14802       32.75343
 PNT Q6     -19.00500        5.37662       30.73824
 PNT D1     -39.75000       -1.88724        2.94760
 PNT D8       0.00000        0.44897        3.47109
 PNT D14    -24.32115       -0.76529        3.41531
 PNT Q13    -29.57760       -8.34798       29.02334
 PNT Q14    -28.45620       -6.76688       29.43210
 PNT Q15    -26.96420       -4.67152       29.83648
 PNT Q17    -28.79770       -4.52851       10.44389
 PNT Q19    -23.49029       -3.18952       12.57775
 PNT Q20    -19.15449       -1.82687       14.66692
 PNT Q21    -23.68410        0.40677       30.33370
 PNT Q22    -21.14080        3.47937       30.45073
 PNT Q23    -17.08270        6.80114       31.25868
 PNT Q24    -11.84980        0.86934       19.14112
 PNT Q25     -9.23330        2.11690       21.53638
 PNT Q26    -15.42740        7.93285       31.94235
 PNT Q28    -12.33030       10.62113       33.92821
 PNT Q30    -11.04880       11.99328       35.17982
 PNT Q32     -9.53990       14.57698       36.98126
 PNT Q33     -8.84563       16.24017       38.08675
 PNT Q36     -8.37704       17.47106       38.77111
 PNT Q37     -1.24058       20.99273       38.03943
 PNT Q38     -8.06465       18.98126       38.94064
 PNT Q39    -10.20380       14.29173       35.76020
 PNT Q40     -8.37990       18.18701       38.53180
 PNT Q41     -8.87660       16.91988       37.77082
 PNT Q42     -9.53990       15.43101       36.63317
 PNT Q43     -2.54377       12.31851       31.38150
 PNT Q44     -2.04382       13.82011       32.98211
 PNT Q45     -1.72389       16.09755       34.95285
 PNT Q46     -1.45415       18.64171       36.80389
 PNT Q47    -14.23200       10.34056       32.16419
 PNT Q48    -11.36450       12.85118       34.40602
 PNT Q49    -12.77430       11.49403       33.14696
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 SEQA S001     pnt  P04Z P056 P054 P052 P050
 SEQA S002     pnt  Q37 Q46 Q45 Q44 Q43
 SEQA S003     pnt  Q43 Q52 Q51 Q50
 SEQA S004     pnt  Q50 Q58 Q57 Q56
 SEQA S005     pnt  Q56 Q61 Q60 Q59
 SEQA S006     pnt  Q59 Q68 Q67 Q66 Q65
 SEQA S007     pnt  Q65 P05A P059 P058
 SEQA S008     pnt  P050 P05A P059 P058
 SEQA S009     pnt  P058 Q25 Q24 P05C
 SEQA S00A     pnt  P05C Q20 Q19 P05G
 SEQA S00C     pnt  P05G P05N Q17 P05L P3
 SEQA S00E     pnt  Q38 Q40 Q41 Q42 Q39
 SEQA S00G     pnt  Q39 Q48 Q49 Q47
 SEQA S00I     pnt  Q47 Q54 Q55 Q53
 SEQA S00J     pnt  Q53 Q63 Q64 Q62
 SEQA S00K     pnt  Q62 Q70 Q71 Q72 Q69
 SEQA S00L     pnt  P8 Q13 Q14 Q15 P7
 SEQA S00N     pnt  P7 Q21 Q22 Q6
 SEQA S00O     pnt  Q6 Q23 Q26 Q4
 SEQA S00P     pnt  Q4 Q28 Q30 Q1
 SEQA S00R     pnt  Q1 Q32 Q33 Q36 P6
 SEQA S00S     pnt  QA4U QA53 QA52 QA51 QA50
 SEQA S00T     pnt  QA50 QA5J QA5I QA5H
 SEQA S00V     pnt  QA5H QA5V QA5U QA5T
 SEQA S00W     pnt  QA5T QA64 QA63 QA62
 SEQA S00X     pnt  QA62 QA6H QA6G QA6F QA6E
 SEQA S01L     pnt  P04Z P056 P054 P052 P050
 SEQA S01M     pnt  P050 P05A P059 P058
 SEQA S01N     pnt  P058 Q25 Q24 P05C
 SEQA S01P     pnt  P05C Q20 Q19 P05G
 SEQA S01Q     pnt  P05G P05N Q17 P05L P3
 SEQA S014     pnt  P04Z P00W P00O
 SEQA S015     pnt  P050 P00X P00P
 SEQA S016     pnt  P058 P00Z P00R
 SEQA S017     pnt  P05C P010 P00S
 SEQA S019     pnt  P05G P011 P00T
 SEQA S01A     pnt  P00V P012 P3
 SEQA S01S     pnt  P04Z P01J Q37
 SEQA S01T     pnt  P050 P01K Q43
 SEQA S01U     pnt  P058 P01L Q50
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 LINE L015 P050 P00P S015 104
 LINE L01C P05G P00T S019 104
 LINE L01A P05C P00S S017 104
 LINE L017 P058 P00R S016 104
 LINE L01E P8 P00V 106
 LINE E1 D1 P05R 104
 LINE E9 P05Z P05Y 104
 LINE E10 P05Y P05W 104
 LINE E11 P05W D8 -414
 LINE E12 D8 D14 214
 LINE E13 D14 P05S 104
 LINE E14 P05S D1 102
 LINE L001 P04Z P050 S001 104
 LINE L002 Q37 Q43 S002 104
 LINE L003 Q43 Q50 S003 104
 LINE L004 Q50 Q56 S004 106
 LINE L005 Q56 Q59 S005 106
 LINE L006 Q59 Q65 S006 104
 LINE L008 P050 P058 S008 104
 LINE L009 P058 P05C S009 106
 LINE L00A P05C P05G S00A 106
 LINE L00C P05G P3 S00C 104
 LINE L00E Q38 Q39 S00E 104
 LINE L00G Q39 Q47 S00G 104
 LINE L00I Q47 Q53 S00I 106
 LINE L00J Q53 Q62 S00J 106
 LINE L00K Q62 Q69 S00K 104
 LINE L00L P8 P7 S00L 104
 LINE L00N P7 Q6 S00N 106
 LINE L00O Q6 Q4 S00O 106
 LINE L00P Q4 Q1 S00P 104
 LINE L00R Q1 P6 S00R 104
 LINE L00S QA4U QA50 S00S 104
 LINE L00T QA50 QA5H S00T 104
 LINE L00V QA5H QA5T S00V 106
 LINE L00W QA5T QA62 S00W 106
 LINE L00X QA62 QA6E S00X 104
 LINE U84 P04Z Q37 S01S 104
 LINE U85 P6 Q38 104
 LINE L01J Q43 P014 S01H 104
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 LCMB C001  + L013 + L014
 LCMB C002  + L015 + L016
 LCMB C003  + L017 + L019
 LCMB C004  + L01A + L01B
 LCMB C005  + L01C + L01D
 LCMB C006  + L01E + L01F
 LCMB C007  + L01H + L01I
 LCMB C008  + L01J + L01K
 LCMB C009  + L01L + L01M
 LCMB C00A  + L01N + L01P
 LCMB C00C  + L01S + L01T
 LCMB C00E  + L01U + L01V
 LCMB C00G  + L066 + L068
 LCMB C00J  + L01Y + L069
 LCMB C00K  + L024 + L06B
 LCMB C00N  + L022 + L06C
 LCMB C00O  + L020 + L06D
 LCMB C00S  + L06I + L06J
 LCMB C00V  + L03G + L06L
 LCMB C00W  + L03J + L06M
 LCMB C00Z  + L03N + L06N
 LCMB C011  + L06H + L06P
 GSUR A001 - BLEND + UATI + UATH - UATD - L00S
 GSUR A002 - BLEND + UATD + UATC - UAT8 - L00T
 GSUR A003 - BLEND + UAT8 + UAT7 - UAT3 - L00V
 GSUR A004 - BLEND + UAT3 + UAT2 - UASY - L00W
 GSUR A005 - BLEND + UASY + UASX - UASO - L00X
 GSUR V15 - BLEND + C001 + U85 - C007 - U84
 GSUR A006 + BLEND - L00C + C005 - L00L + C006
 GSUR V17 + BLEND + C002 + U87 - C008 - U93
 GSUR A007 + BLEND + L00L + U127 + L00K - U139
 GSUR A008 + BLEND - L00K - C00C + L006 - C00E
 GSUR A009 + BLEND - L006 - U122 + L00C + U133
 GSUR V21 + BLEND + C003 + U100 - C009 - U105
 GSUR A00A + BLEND - L00A + C004 - L00N - C005
 GSUR A00C + BLEND + L00N + U111 + L00J - U127
 GSUR A00E + BLEND - L00J - C00A + L005 + C00C
 GSUR V25 + BLEND + C004 + U111 - C00A - U116
 GSUR A00G + BLEND - L005 - U116 + L00A + U122
 GSUR A00I + BLEND - L009 + C003 - L00O - C004
 GSUR A00J + BLEND + L00O + U100 + L00I - U111
 GSUR A00K + BLEND - L00I - C009 + L004 + C00A
 GSUR V30 + BLEND + C005 + U127 - C00C - U122
 GSUR A00L + BLEND - L004 - U105 + L009 + U116
 GSUR A00N + BLEND - L008 + C002 - L00P - C003
 GSUR A00O + BLEND + L00P + U87 + L00G - U100
 GSUR V34 - BLEND + C006 + U133 - C00E - U139
 GSUR A00P + BLEND - L00G - C008 + L003 + C009
 GSUR V569 + BLEND + E1 + UANV + UANW + E14
 GSUR A00R + BLEND - L003 - U93 + L008 + U105
 GSUR A00S + BLEND - L001 + C001 - L00R - C002
 GSUR A00T + BLEND + L00R + U85 + L00E - U87
 GSUR A00V + BLEND - L00E - C007 + L002 + C008
 GSUR A00W + BLEND - L002 - U84 + L001 + U93
 GSUR V576 + BLEND + E1 + UAO4 - UAO5 - UAO3
 GSUR V577 + BLEND + UANV + U133 - UAO7 - UAO4
 GSUR V578 + BLEND + UANW + UAO8 - UAO9 - U133
 GSUR V579 + BLEND + E14 + UAO3 - UAOA - UAO8
 GSUR V580 + BLEND + UAO5 + UAO7 + UAO9 + UAOA
 GSUR V582 + BLEND + E13 + UAO8 - UAOI - UAOH
 GSUR V583 + BLEND + UANX + UAOH - UAOJ - U122
 GSUR A00X + BLEND - L001 + UAO1 + E9 - UAO0
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 GBOD B001 NORM - V30 - V34 + A008 + A007 + A006 + A009
 GBOD B002 NORM - V25 + V30 + A00E + A00C + A00A + A00G
 GBOD B003 NORM - V21 + V25 + A00K + A00J + A00I + A00L
 GBOD B004 NORM - V17 + V21 + A00P + A00O + A00N + A00R
 GBOD B005 NORM - V15 + V17 + A00V + A00T + A00S + A00W
 GBOD W119 NORM - V569 + V580 + V578 + V577 + V576 + V579
 GBOD B006 NORM + V599 - V595 - A00Z - A00W - A00X + V598
 GBOD B007 NORM - V671 + V668 + A001 + A010 + A00Z - V670
 GBOD B008 NORM - V668 + V665 + A002 + A012 + A011 - V667
 GBOD B009 NORM + V595 - V591 - A011 - A00R - A013 + V594
 GBOD B00A NORM - V665 + V662 + A003 + A015 + A014 - V664
 GBOD W136 NORM - V580 + V627 + V655 + V654 + V653 + V656
 GBOD B00C NORM + V591 - V587 - A014 - A00L - A016 + V590
 GBOD B00E NORM + V587 - V583 - A019 - A00G - A017 + V586
 GBOD B00G NORM - V662 + V659 + A004 + A01A + A019 - V661
 GBOD B00I NORM + V583 - V578 - A01C - A009 - A01B + V582
 GBOD B00J NORM - V659 - V655 + A005 + A01D + A01C - V658
 GBOD B00L NORM - A01V + A024 + A01U + A01T + A01S + A01X
 GBOD B00N NORM - A01R + A01V + A022 + A020 + A01Y + A026
 GBOD B00O NORM - A01M + A01R + A02D + A029 + A028 + A02F
 GBOD B00P NORM - A01K + A01M + A02J + A02I + A02G + A02K
 GBOD B00R NORM - A02E + A02R + A02O + A02M + A02L + A02Q
 GBOD B00S NORM + A039 - A034 - A02Z - A02K - A02V + A037
 GBOD B00T NORM - A045 + A041 + A00X + A032 + A02Z - A044
 GBOD B00V NORM - A041 + A03X + A013 + A03A + A036 - A040
 GBOD B00W NORM + A034 - A031 - A036 - A02F - A03C + A033
 GBOD B00X NORM - A03X + A03U + A016 + A03F + A03E - A03W
 GBOD B00Z NORM - A02R + V569 + A03K + A03J + A03I + A03M
 GBOD B010 NORM + A031 - A02Y - A03E - A026 - A03G + A030
 GBOD B011 NORM + A02Y - A02U - A03N - A01X - A03H + A02W
 GBOD B012 NORM - A03U + A03P + A017 + A03R + A03N - A03S
 GBOD B013 NORM + A02U - A02O - A03Z - A01Q - A03V + A02T
 GBOD B014 NORM - A03P - A03K + A01B + A043 + A03Z - A03O
 SETA l l L002
 SETA l l L003
 SETA l l L004
 SETA l l L005
 SETA l l L006
 SETA CYC1 p QA4U
 SETA CYC1 p QA50
 SETA CYC1 p QA51
 SETA CYC1 p QA52
 SETA CYC1 p QA53
 SETA CYC1 p QA5H
 SETA CYC1 p QA5I
 SETA CYC1 p QA5J
 SETA CYC1 p QA5T
 SETA CYC1 p QA5U
 SETA CYC1 p QA5V
 SETA CYC1 p QA62
 SETA CYC1 p QA63
 SETA CYC1 p QA64
 SETA CYC1 p QA6E
 SETA CYC1 p QA6F
 SETA CYC1 p QA6G
 SETA CYC1 p QA6H
 SETA CYC1 p QA6U
 SETA CYC1 p QA6V
 SETA CYC1 p QA6W
 SETA CYC1 p QA70
 SETA CYC1 p QA72
 SETA CYC1 p QA74
 SETA CYC1 p QA76
 SETA CYC1 p QA78
 SETA CYC1 l L00S
 SETA CYC1 l L00T
 SETA CYC1 l L00V
 SETA CYC1 l L00W
 SETA CYC1 l L00X
 SETA CYC1 l UASM
 SETA CYC1 l UASN
 SETA CYC1 l UASO
 SETA CYC1 l UASP
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 ELTY all HE20
 plot l SPC k
 plus p SPC b
 plus s SPC m
 plus b all g
 plus sa CYC1 m
