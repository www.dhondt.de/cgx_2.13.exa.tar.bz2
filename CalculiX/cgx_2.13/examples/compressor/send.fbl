read lavff.fbd
del me
elty all
elty all he20r
mesh all
send SPC abq spc 23
send CYC1 abq nam
send CYC2 abq nam
send all abq
quit
