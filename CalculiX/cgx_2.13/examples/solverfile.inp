***********************************************************************
*HEADING
Compressor of a Turbocharger, cyclic symetrie
***********************************************************************
**                      UNITS
**   Temp(K), Length(MM), Force(N), Density(10**3*KG/MM**3)
***********************************************************************
**
*NODE, NSET=Nall
       1,0.000000000000e+00,-1.689779500000e+01,5.587957000000e+01
       2,-1.523037127527e-07,-1.633762325000e+01,5.596218200000e+01
       3,-1.500000145478e+00,-1.633762368750e+01,5.596218100000e+01
       4,-1.500000000000e+00,-1.689779550000e+01,5.587956900000e+01
       5,-4.367158865648e-07,-1.647589525000e+01,5.666871825000e+01
       6,-4.996611409069e-07,-1.602861819916e+01,5.660224779298e+01
       7,-1.500000474000e+00,-1.602861856784e+01,5.660224719621e+01
       8,-1.500000415037e+00,-1.647589568750e+01,5.666871750000e+01
       9,-7.615185637633e-08,-1.661770912500e+01,5.592087600000e+01
      10,-7.500001488907e-01,-1.633762346875e+01,5.596218150000e+01
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*ELEMENT, TYPE=C3D20R, ELSET=Eall
     1,     1,     2,     3,     4,     5,     6,     7,     8,     9,    10,
          11,    12,    17,    18,    19,    20,    13,    14,    15,    16
     2,     4,     3,    21,    22,     8,     7,    23,    24,    11,    25,
          26,    27,    19,    30,    31,    32,    16,    15,    28,    29
     3,    22,    21,    33,    34,    24,    23,    35,    36,    26,    37,
          38,    39,    31,    42,    43,    44,    29,    28,    40,    41
     4,    34,    33,    45,    46,    36,    35,    47,    48,    38,    49,
          50,    51,    43,    54,    55,    56,    41,    40,    52,    53
     5,     5,     6,     7,     8,    57,    58,    59,    60,    17,    18,
          19,    20,    65,    66,    67,    68,    61,    62,    63,    64
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** Names based on SPC
*NSET,NSET=NSPC
1127,
1128,
1132,
1134,
1136,
1138,
1140,
1142,
1144,
3061,
3062,
3066,
3073,
3075,
3080,
3082,
3087,
3089,
*BOUNDARY
Nspc,1,3
**MATERIALPARAMETER:
***********************************************************************
**MATERIALPARAMETER AT 293 K
***********************************************************************
*MATERIAL,NAME=C355
*ELASTIC
.75E5,0.3
*DENSITY
2.65E-9
*SOLID SECTION,ELSET=Eall,MATERIAL=C355
**
*INITIAL CONDITIONS, TYPE=TEMPERATURE
Nall, 293.0
**
*STEP
*FREQUENCY,EIGENSOLVER=LANCZOS
10
*NODE PRINT,FREQUENCY=0
*EL PRINT,FREQUENCY=0
*NODE FILE,FREQUENCY=1
U
*EL FILE,FREQUENCY=1,POSITION=AVERAGED AT NODES
S
*END STEP
