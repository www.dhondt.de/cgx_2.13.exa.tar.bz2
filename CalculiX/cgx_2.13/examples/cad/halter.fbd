 PNT D001  -1.500000000000e+01  1.500000000000e+01  -3.000000000000e+01
 PNT D002  -1.500000000000e+01  0.000000000000e+00  -3.000000000000e+01
 PNT D003  -1.500000000000e+01  6.350244140625e+00  -3.000000000000e+01
 PNT D004  -2.000000000000e+00  2.086824000000e+01  -6.678015000000e+01
 PNT D005  -2.000000000000e+00  2.072501000000e+01  -6.680541000000e+01
 PNT D006  -2.000000000000e+00  2.058067000000e+01  -6.682441000000e+01
 PNT D007  -2.000000000000e+00  2.043578000000e+01  -6.683709000000e+01
 PNT D008  -2.000000000000e+00  2.029089000000e+01  -6.684976000000e+01
 PNT D009  -2.000000000000e+00  2.014544000000e+01  -6.685611000000e+01
 PNT D00A  -2.000000000000e+00  2.000000000000e+01  -6.685611000000e+01
 PNT D00B  -2.000000000000e+00  2.072630937591e+01  -6.680307933391e+01
 PNT D00C  -2.000000000000e+00  2.058377582646e+01  -6.682191752979e+01
 PNT D00D  -2.000000000000e+00  2.044075956781e+01  -6.683665170733e+01
 PNT D00E  -2.000000000000e+00  2.029737810305e+01  -6.684726040976e+01
 PNT D00F  -2.000000000000e+00  2.015374992270e+01  -6.685374520583e+01
 PNT D00G  -2.000000000000e+00  2.000999738568e+01  -6.685609999905e+01
 PNT D00H  -4.800000000000e+01  1.280000000000e+02  -1.200000000000e+01
 PNT D00I  -4.400000000000e+01  1.280000000000e+02  -1.200000000000e+01
 PNT D00J  -4.569339843750e+01  1.280000000000e+02  -1.200000000000e+01
 PNT D00K  -3.000000000000e+01  9.000000000000e+01  -1.200000000000e+01
 PNT D00L  -2.000000000000e+01  9.000000000000e+01  -1.200000000000e+01
 PNT D00M  -2.423349609375e+01  9.000000000000e+01  -1.200000000000e+01
 PNT D00N  -4.800000000000e+01  2.000000000000e+01  -6.685611000000e+01
 PNT D00O  -4.800000000000e+01  2.014544000000e+01  -6.685611000000e+01
 PNT D00P  -4.800000000000e+01  2.029089000000e+01  -6.684976000000e+01
 PNT D00Q  -4.800000000000e+01  2.043578000000e+01  -6.683709000000e+01
 PNT D00R  -4.800000000000e+01  2.058067000000e+01  -6.682441000000e+01
 PNT D00S  -4.800000000000e+01  2.072501000000e+01  -6.680541000000e+01
 PNT D00T  -4.800000000000e+01  2.086824000000e+01  -6.678015000000e+01
 PNT D00U  -4.800000000000e+01  2.014375663411e+01  -6.685404262795e+01
 PNT D00V  -4.800000000000e+01  2.028739742013e+01  -6.684784480523e+01
 PNT D00W  -4.800000000000e+01  2.043079999514e+01  -6.683752297199e+01
 PNT D00X  -4.800000000000e+01  2.057384535285e+01  -6.682307499189e+01
 PNT D00Y  -4.800000000000e+01  2.071641635673e+01  -6.680452175418e+01
 PNT D00Z  -4.800000000000e+01  2.085839279453e+01  -6.678187648280e+01
 PNT D010  -3.950000000000e+01  3.000000000000e+02  -1.750000000000e+00
 PNT D011  -3.874892000000e+01  3.000000000000e+02  -3.000000000000e+00
 PNT D012  -3.906688942461e+01  3.000000000000e+02  -2.470812988281e+00
 PNT D013  -4.400000000000e+01  3.280000000000e+02  0.000000000000e+00
 PNT D014  -4.400000000000e+01  2.920000000000e+02  0.000000000000e+00
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 SEQA A002     pnt  D001 D003 D002
 SEQA A003     pnt  D004 D00B D00C D00D D00E D00F D00G D00A
 SEQA A004     pnt  D00H D00J D00I
 SEQA A005     pnt  D00K D00M D00L
 SEQA A006     pnt  D00N D00U D00V D00W D00X D00Y D00Z D00T
 SEQA A007     pnt  D010 D012 D011
 SEQA A008     pnt  D013 D015 D014
 SEQA A009     pnt  D016 D018 D017
 SEQA A00A     pnt  D019 D01B D01A
 SEQA A00B     pnt  D014 D01E D01D
 SEQA A00C     pnt  D01F D01H D001
 SEQA A00D     pnt  D01I D01K D01J
 SEQA A00E     pnt  D01L D02A D02B D02C D02D D02E D02F D02G D02H D02I
 SEQA A00E END pnt  D02J D02K D02L D02M D02N D02O D02P D02Q D02R D02S
 SEQA A00E END pnt  D02T D02U D029
 SEQA A00F     pnt  D02V D02X D004
 SEQA A00G     pnt  D02Y D04B D04C D04D D04E D04F D04G D04H D04I D04J
 SEQA A00G END pnt  D04K D04L D04M D04N D04O D04P D04Q D04R D04S D04T
 SEQA A00G END pnt  D04U D04V D04W D04X D04Y D04Z D050 D051 D052 D053
 SEQA A00G END pnt  D054 D055 D056 D057 D058 D059 D05A D05B D05C D05D
 SEQA A00G END pnt  D05E D05F D05G D04A
 SEQA A00H     pnt  D05H D066 D067 D068 D069 D06A D06B D06C D06D D06E
 SEQA A00H END pnt  D06F D06G D06H D06I D06J D06K D06L D06M D06N D06O
 SEQA A00H END pnt  D06P D06Q D065
 SEQA A00I     pnt  D06R D07G D07H D07I D07J D07K D07L D07M D07N D07O
 SEQA A00I END pnt  D07P D07Q D07R D07S D07T D07U D07V D07W D07X D07Y
 SEQA A00I END pnt  D07Z D080 D081 D082 D083 D084 D085 D086 D087 D088
 SEQA A00I END pnt  D089 D08A D08B D08C D08D D08E D08F D08G D08H D08I
 SEQA A00I END pnt  D08J D08K D08L D08M D08N D017
 SEQA A00J     pnt  D08O D0A1 D0A2 D0A3 D0A4 D0A5 D0A6 D0A7 D0A8 D0A9
 SEQA A00J END pnt  D0AA D0AB D0AC D0AD D0AE D0AF D0AG D0AH D0AI D0AJ
 SEQA A00J END pnt  D0AK D0AL D0AM D0AN D0AO D0AP D0AQ D0AR D0AS D0AT
 SEQA A00J END pnt  D0AU D0AV D0AW D0AX D0AY D0AZ D0B0 D0B1 D0B2 D0B3
 SEQA A00J END pnt  D0B4 D0B5 D0B6 D0A0
 SEQA A00K     pnt  D0B7 D0B9 D0B8
 SEQA A00L     pnt  D0BA D0BC D0BB
 SEQA A00M     pnt  D0BD D0BF D0BE
 SEQA A00N     pnt  D0BG D0C5 D0C6 D0C7 D0C8 D0C9 D0CA D0CB D0CC D0CD
 SEQA A00N END pnt  D0CE D0CF D0CG D0CH D0CI D0CJ D0CK D0CL D0CM D0CN
 SEQA A00N END pnt  D0CO D0CP D0C4
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 LINE Q001 D001 D002 A002 108
 LINE Q002 D004 D00A A003 102
 LINE Q003 D00H D00I A004 102
 LINE Q004 D00K D00L A005 106
 LINE Q005 D00N D00T A006 102
 LINE Q006 D010 D011 A007 102
 LINE Q007 D013 D014 A008 118
 LINE Q008 D016 D017 A009 102
 LINE Q009 D019 D01A A00A 108
 LINE Q00A D014 D01D A00B 102
 LINE Q00B D01F D001 A00C 106
 LINE Q00C D01I D01J A00D 102
 LINE Q00D D01L D029 A00E 106
 LINE Q00E D02V D004 A00F 102 1.000000
 LINE Q00F D02Y D04A A00G 112
 LINE Q00G D05H D065 A00H 106
 LINE Q00H D06R D017 A00I 106
 LINE Q00I D08O D0A0 A00J 108
 LINE Q00J D0B7 D0B8 A00K 106
 LINE Q00K D0BA D0BB A00L 112
 LINE Q00L D0BD D0BE A00M 102
 LINE Q00M D0BG D0C4 A00N 106
 LINE Q00N D0CQ D0DE A00O 106
 LINE Q00O D029 D0EO A00P 134
 LINE Q00P D0EQ D0ER A00Q 132
 LINE Q00Q D0ET D0G5 A00R 108
 LINE Q00R D0HC D0HD A00S 106
 LINE Q00S D0HF D0IR A00T 112
 LINE Q00T D0JY D0JZ A00U 106
 LINE Q00U D0K1 D0K2 A00V 102
 LINE Q00V D0K4 D0K5 A00W 102
 LINE Q00W D0K7 D00N A00X 106
 LINE Q00X D0LH D0LI A00Y 114
 LINE Q00Y D0LK D0K5 A00Z 116
 LINE Q00Z D0LN D0LT A010 102
 LINE Q010 D0IR D0HF A011 112
 LINE Q011 D0OJ D0B7 A012 106
 LINE Q012 D0PT D013 A013 102
 LINE Q013 D002 D0PX A014 110
 LINE Q014 D0PZ D0QN A015 106
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 NURS N001 DEFINE    3    3   49    4   53    8
 NURS N001 CONTROL    1    1 D5CP 1.000000
 NURS N001 CONTROL    1    2 D5CS 1.000000
 NURS N001 CONTROL    1    3 D5CV 1.000000
 NURS N001 CONTROL    1    4 D5CY 1.000000
 NURS N001 CONTROL    2    1 D5CQ 1.000000
 NURS N001 CONTROL    2    2 D5CT 1.000000
 NURS N001 CONTROL    2    3 D5CW 1.000000
 NURS N001 CONTROL    2    4 D5CZ 1.000000
 NURS N001 CONTROL    3    1 D5CR 1.000000
 NURS N001 CONTROL    3    2 D5CU 1.000000
 NURS N001 CONTROL    3    3 D5CX 1.000000
 NURS N001 CONTROL    3    4 D5D0 1.000000
 NURS N001 CONTROL    4    1 D5D1 1.000000
 NURS N001 CONTROL    4    2 D5D4 1.000000
 NURS N001 CONTROL    4    3 D5D7 1.000000
 NURS N001 CONTROL    4    4 D5DA 1.000000
 NURS N001 CONTROL    5    1 D5D2 1.000000
 NURS N001 CONTROL    5    2 D5D5 1.000000
 NURS N001 CONTROL    5    3 D5D8 1.000000
 NURS N001 CONTROL    5    4 D5DB 1.000000
 NURS N001 CONTROL    6    1 D5D3 1.000000
 NURS N001 CONTROL    6    2 D5D6 1.000000
 NURS N001 CONTROL    6    3 D5D9 1.000000
 NURS N001 CONTROL    6    4 D5DC 1.000000
 NURS N001 CONTROL    7    1 D5DD 1.000000
 NURS N001 CONTROL    7    2 D5DG 1.000000
 NURS N001 CONTROL    7    3 D5DJ 1.000000
 NURS N001 CONTROL    7    4 D5DM 1.000000
 NURS N001 CONTROL    8    1 D5DE 1.000000
 NURS N001 CONTROL    8    2 D5DH 1.000000
 NURS N001 CONTROL    8    3 D5DK 1.000000
 NURS N001 CONTROL    8    4 D5DN 1.000000
 NURS N001 CONTROL    9    1 D5DF 1.000000
 NURS N001 CONTROL    9    2 D5DI 1.000000
 NURS N001 CONTROL    9    3 D5DL 1.000000
 NURS N001 CONTROL    9    4 D5DO 1.000000
 NURS N001 CONTROL   10    1 D5DP 1.000000
 NURS N001 CONTROL   10    2 D5DS 1.000000
 NURS N001 CONTROL   10    3 D5DV 1.000000
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 GSUR A001 + N003 - Q00M + Q075 + Q01E - Q06T
 GSUR A002 + N005 + Q00Y + Q027 - Q03O - Q04N + Q06S + Q022 + Q04A + Q039
 GSUR A003 + N006 - Q029 + Q03O + Q01Z - Q025
 GSUR A004 + N008 - Q05C - Q01P - Q01Q + Q06K
 GSUR A005 + N009 - Q065 + Q042 + Q03S + Q078
 GSUR A006 + N00B - Q06J + Q05S - Q04Y + Q01X
 GSUR A007 + N00E - Q02N - Q056 - Q03L
 GSUR A008 + N00F - Q06D + Q04W + Q058 + Q06C
 GSUR A009 + N00G - Q044 - Q06R - Q03A
 GSUR A00A + N00H + Q020 - Q03Z + Q04K + Q03R
 GSUR A00B + N00I - Q04B - Q06K - Q00K - Q05D
 GSUR A00C + N00R - Q05S - Q03G - Q01X - Q055
 GSUR A00D + N00S - Q00F + Q01I - Q04F + Q04P
 GSUR A00E + N00T + Q07G - Q06W - Q05G + Q02H + Q03I + Q06D + Q05M + Q00N
 GSUR A00F + N00U - Q053 - Q04Z - Q076 + Q03L
 GSUR A00G + N00X - Q06S - Q03T + Q063 - Q01J
 GSUR A00H + N010 + Q00U + Q045 - Q04H
 GSUR A00I + N011 - Q03X - Q070 - Q017
 GSUR A00J + N017 + Q056 + Q02N - Q030
 GSUR A00K + N019 - Q00S + Q019 - Q04J + Q02I
 GSUR A00L + N01E + Q06R + Q044 - Q03B
 GSUR A00M + N01G - Q019 - Q010 - Q02I - Q035
 GSUR A00N + N01H + Q03T - Q022 + Q01J + Q00H
 GSUR A00O + N01I - Q05N + Q053 + Q030 + Q076
 GSUR A00P + N01J - Q02Y - Q054 + Q017 - Q02X
 GSUR A00Q + N01M - Q032 - Q03C - Q05P + Q038
 GSUR A00R + N01N + Q06H + Q05D - Q03D - Q048 + Q034 + Q00Q
 GSUR A00S + N01P - Q049 - Q04S - Q05K
 GSUR A00T + N01Q + Q06W + Q03W - Q01Y - Q04T
 GSUR A00U + N01R + Q070 + Q03X - Q02C
 GSUR A00V + N01S - Q03H + Q04L - Q05X + Q05E
 GSUR A00W + N01T + Q00K + Q01Q + Q036 - Q00X - Q03F + Q03D
 GSUR A00X + N01U + Q016 + Q02K - Q00J - Q011
 GSUR A00Y + N01V - Q01I - Q01H - Q04P - Q03Q
 GSUR A00Z + N01W + Q02Z + Q013 + Q01O - Q02G + Q061 + Q06A - Q01A - Q00R
 GSUR A00Z ADD + Q010 + Q00S + Q01H + Q00F + Q03G + Q06J + Q069 + Q03H
 GSUR A010 + N01X - Q05L - Q059 + Q03N + Q05T + Q00Z + Q031
 GSUR A011 + N01Y - Q021 - Q07F - Q038
 GSUR A012 + N01Z - Q00A - Q05V + Q057 - Q05F
 GSUR A013 + N020 - Q04L - Q069 - Q05E - Q01C
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 SETA A001 p D001
 SETA A001 p D002
 SETA A001 p D003
 SETA A001 p D004
 SETA A001 p D005
 SETA A001 p D006
 SETA A001 p D007
 SETA A001 p D008
 SETA A001 p D009
 SETA A001 p D00A
 SETA A001 p D00B
 SETA A001 p D00C
 SETA A001 p D00D
 SETA A001 p D00E
 SETA A001 p D00F
 SETA A001 p D00G
 SETA A001 p D00H
 SETA A001 p D00I
 SETA A001 p D00J
 SETA A001 p D00K
 SETA A001 p D00L
 SETA A001 p D00M
 SETA A001 p D00N
 SETA A001 p D00O
 SETA A001 p D00P
 SETA A001 p D00Q
 SETA A001 p D00R
 SETA A001 p D00S
 SETA A001 p D00T
 SETA A001 p D00U
 SETA A001 p D00V
 SETA A001 p D00W
 SETA A001 p D00X
 SETA A001 p D00Y
 SETA A001 p D00Z
 SETA A001 p D010
 SETA A001 p D011
 SETA A001 p D012
 SETA A001 p D013
 SETA A001 p D014
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 plot lp all k
 plus si all m
