 PNT P3      13.98710        0.85058       40.42490
 PNT P4      21.99990        7.49557       35.52520
 PNT P5      27.06742        4.88009       19.06155
 PNT P6      27.09289        1.35024       12.48617
 PNT P7      14.00477       -2.96147       14.22214
 PNT P8       4.24678       -1.50800       20.98534
 PNT P11      0.66250        1.24841       28.11380
 PNT Q1       0.63534        2.94966       40.46316
 PNT Q2      15.78270        1.79820       38.53260
 PNT Q3       3.15740        1.63613       40.53740
 PNT Q4       5.12370        0.54452       40.56700
 PNT Q5       7.33920       -0.23770       40.57120
 PNT Q6       9.96100       -0.49360       40.56690
 PNT Q7      12.20820        0.00399       40.59420
 PNT Q8      14.84330        1.28130       39.51350
 PNT Q9      17.24908        2.78339       37.42750
 PNT Q10     19.05929        4.29833       36.52250
 PNT Q11      2.07334        0.08070       25.28752
 PNT Q12      6.73596       -2.49387       17.49376
 PNT Q13      9.70445       -3.20596       15.25111
 PNT Q14     20.69047       -1.34946       13.42933
 PNT Q15     23.43927       -0.26498       13.04975
 PNT Q16     17.47325       -2.32652       13.78279
 PNT Q17      8.78604       -0.74237       34.06115
 PNT Q18      5.92935       -0.19756       32.47051
 PNT Q19      3.19028        0.68437       29.90936
 PNT Q20     10.84765       -0.66904       35.40834
 PNT Q21     13.43935        0.17659       36.94702
 PNT Q22     24.60276        6.83979       27.74372
 PNT Q23      7.28384       -0.77288       29.88752
 PNT Q24     12.11716       -0.54413       34.05553
 PNT Q25      9.31617       -1.33364       26.95230
 PNT Q26     13.49098       -0.25025       32.88145
 PNT Q27     11.64284       -1.55986       24.72154
 PNT Q28     13.61607       -1.46795       23.13652
 PNT Q29     16.08994       -0.95153       21.96243
 PNT Q30     18.79942       -0.04061       20.96446
 PNT Q31     21.39121        1.12947       20.20130
 PNT Q32     24.07133        2.64806       19.55555
 PNT Q33     15.02643        0.23326       31.64864
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 SEQA A00Q     pnt  Q4 Q43 Q18
 SEQA A00R     pnt  Q60 Q65 Q63
 SEQA A00S     pnt  Q6 Q42 Q20
 SEQA A00T     pnt  Q48 Q55 Q53
 SEQA A01N     pnt  Q1 D010 Q103
 SEQA A01M     pnt  P11 D00Z Q106
 SEQA A01L     pnt  Q11 D00U Q109
 SEQA A01K     pnt  Q12 D003 Q111
 SEQA A003     pnt  Q12 Q13 P7 Q16 Q14 Q15 P6
 SEQA A004     pnt  Q111 Q120 Q119 Q118 Q117 Q116 Q114
 SEQA A007     pnt  Q11 P8 Q12
 SEQA A008     pnt  Q109 Q113 Q111
 SEQA A00A     pnt  Q1 Q44 P11
 SEQA A00B     pnt  Q103 Q107 Q106
 SEQA A00C     pnt  Q27 Q28 Q29 Q30 Q31 Q32 P5
 SEQA A00D     pnt  Q76 Q98 Q99 Q100 Q101 Q102 Q96
 SEQA A00E     pnt  Q23 Q25 Q27
 SEQA A00F     pnt  Q71 Q78 Q76
 SEQA A00G     pnt  Q33 Q34 Q35 Q36 Q37 Q38 Q22
 SEQA A00H     pnt  Q73 Q84 Q85 Q86 Q90 Q91 Q82
 SEQA A00I     pnt  Q40 Q10 Q41 P4
 SEQA A00J     pnt  Q79 Q94 Q95 Q92
 SEQA A00O     pnt  Q24 Q26 Q33
 SEQA A00P     pnt  Q69 Q75 Q73
 SEQA A00U     pnt  D022 Q3 Q4
 SEQA A00V     pnt  D024 Q105 Q60
 SEQA A00W     pnt  Q4 Q5 Q6
 SEQA A00X     pnt  Q60 Q62 Q48
 SEQA A00Y     pnt  Q6 Q7 P3
 SEQA A00Z     pnt  Q48 Q52 Q50
 SEQA A010     pnt  Q50 Q59 Q56
 SEQA A011     pnt  P3 Q8 Q2
 SEQA A012     pnt  Q39 Q9 Q40
 SEQA A013     pnt  Q67 Q81 Q79
 SEQA A014     pnt  Q18 Q17 Q20
 SEQA A015     pnt  Q20 Q21 Q2
 SEQA A016     pnt  Q63 Q66 Q53
 SEQA A017     pnt  Q53 Q58 Q56
 SEQA A018     pnt  Q23 Q222 Q24
 SEQA A019     pnt  Q24 Q223 Q39
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 LINE U26 Q11 P11 102
 LINE U53 Q18 Q23 102
 LINE U55 Q20 Q24 102
 LINE L00F Q4 Q18 A00Q 116
 LINE L00H Q60 Q63 A00R 116
 LINE U8 Q2 Q39 102
 LINE U91 Q6 Q48 Q49 104
 LINE U92 P3 Q50 Q51 104
 LINE U96 Q20 Q53 Q54 104
 LINE U100 Q2 Q56 Q57 104
 LINE U107 Q4 Q60 Q61 104
 LINE U111 Q18 Q63 Q64 104
 LINE U118 Q39 Q67 Q68 104
 LINE U119 Q56 Q67 102
 LINE U120 Q24 Q69 Q70 104
 LINE U121 Q53 Q69 102
 LINE U123 Q23 Q71 Q72 104
 LINE U124 Q63 Q71 102
 LINE U126 Q33 Q73 Q74 104
 LINE L00I Q6 Q20 A00S 104
 LINE L00M Q48 Q53 A00T 104
 LINE U130 Q27 Q76 Q77 104
 LINE U135 Q40 Q79 Q80 104
 LINE U140 Q22 Q82 Q83 104
 LINE U148 P4 Q92 Q93 104
 LINE U154 P5 Q96 Q97 104
 LINE U163 Q1 Q103 A01N 108
 LINE U167 P11 Q106 A01M 108
 LINE U174 Q11 Q109 A01L 108
 LINE U175 Q109 Q106 102
 LINE U177 Q12 Q111 A01K 108
 LINE U182 P6 Q114 Q115 108
 LINE L02U P6 D01U D01T 102
 LINE L02V Q114 D01W D01V 102
 LINE L02W Q111 D01Y D01X 102
 LINE L033 P11 D026 D025 102
 LINE L034 Q106 D028 D027 102
 LINE L035 Q109 D02A D029 102
 LINE L036 Q11 D02C D02B 102
 LINE L037 Q12 D02E D02D 102
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 LCMB L5  - L044 - L02U
 LCMB U6  + L03G
 LCMB U47  + L03V
 LCMB U48  + L03U
 LCMB U49  + L00F
 LCMB U51  + L00I
 LCMB U2  + L036 + L040
 LCMB U3  + L02A
 LCMB U5  + L037 + L042
 LCMB U7  + L02H
 LCMB U27  + L02B
 LCMB U31  + L02K
 LCMB U32  + L017
 LCMB U37  + L026
 LCMB U38  + L01D
 LCMB U40  + L00Y
 LCMB U43  + L023
 LCMB U76  + L009
 LCMB U78  + L03K
 LCMB U80  + L01W
 LCMB U82  + L03M
 LCMB U85  + L03O
 LCMB U86  + L03I
 LCMB U87  - L00Q - L031
 LCMB U88  - L03Y - L033
 LCMB U89  + L03D
 LCMB U90  + L039
 LCMB U95  + L01B
 LCMB U99  + L00M
 LCMB U103  + L029
 LCMB U106  + L01C
 LCMB U110  + L014
 LCMB U114  + L00H
 LCMB U117  + L028
 LCMB U122  + L02G
 LCMB U125  + L02C
 LCMB U129  + L00A
 LCMB U133  + L03L
 LCMB U134  + L02R
 LCMB U138  + L020
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 GSUR V1 + BLEND - U32 + U51 + U37 - U38
 GSUR V2 + BLEND - U40 + U49 + U43 - U51
 GSUR V3 + BLEND - U8 - U37 + U55 + U27
 GSUR V4 + BLEND - U55 - U43 + U53 + U3
 GSUR V5 + BLEND - U76 - U3 + U78 + U7
 GSUR V6 + BLEND - U80 - U27 + U76 + U31
 GSUR V7 + BLEND - U31 + U82 + U47 - U85
 GSUR V8 + BLEND - U7 + U86 + U48 - U82
 GSUR V9 + BLEND + U87 + U6 - U88 - U49
 GSUR V10 + BLEND - U53 + U88 - U26 + U2
 GSUR V11 + BLEND - U78 - U2 + U89 + U5
 GSUR V12 + BLEND - U5 + U90 - L5 - U86
 GSUR V18 + BLEND + U32 + U92 - U95 - U91
 GSUR V19 + BLEND + U51 + U96 - U99 - U91
 GSUR V20 + BLEND - U37 + U96 + U103 - U100
 GSUR V21 + BLEND + U38 + U100 - U106 - U92
 GSUR V22 + BLEND - U95 + U99 + U103 - U106
 GSUR V23 + BLEND + U40 + U91 - U110 - U107
 GSUR V24 + BLEND + U49 + U111 - U114 - U107
 GSUR V25 + BLEND - U43 + U111 + U117 - U96
 GSUR V26 + BLEND - U110 + U114 + U117 - U99
 GSUR V27 + BLEND + U8 + U118 - U119 - U100
 GSUR V28 + BLEND + U55 + U120 - U121 - U96
 GSUR V29 + BLEND + U27 + U118 - U122 - U120
 GSUR V30 + BLEND - U119 - U103 + U121 + U122
 GSUR V31 + BLEND + U53 + U123 - U124 - U111
 GSUR V32 + BLEND + U3 + U120 - U125 - U123
 GSUR V33 + BLEND - U121 - U117 + U124 + U125
 GSUR V34 + BLEND + U76 + U126 - U129 - U120
 GSUR V35 + BLEND + U78 + U130 - U133 - U123
 GSUR V36 + BLEND + U7 + U126 - U134 - U130
 GSUR V37 + BLEND - U129 - U125 + U133 + U134
 GSUR V38 + BLEND + U80 + U135 - U138 - U118
 GSUR V39 + BLEND + U31 + U135 - U139 - U126
 GSUR V40 + BLEND - U138 - U122 + U129 + U139
 GSUR V41 + BLEND + U82 + U140 - U147 - U126
 GSUR V42 + BLEND - U47 + U140 + U149 - U148
 GSUR V43 + BLEND + U85 + U148 - U153 - U135
 GSUR V44 + BLEND - U139 + U147 + U149 - U153
 GSUR V45 + BLEND + U86 + U154 - U161 - U130
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 GBOD W1 NORM + V1 - V22 + V20 + V21 + V18 - V19
 GBOD W2 NORM + V2 - V26 + V25 + V19 + V23 - V24
 GBOD W3 NORM + V3 - V30 - V28 - V29 + V27 - V20
 GBOD W4 NORM + V4 - V33 - V31 - V32 + V28 - V25
 GBOD W5 NORM + V5 - V37 - V35 - V36 + V34 + V32
 GBOD W6 NORM + V6 - V40 - V34 - V39 + V38 + V29
 GBOD W7 NORM + V7 - V44 + V42 + V43 + V39 - V41
 GBOD W8 NORM + V8 - V47 + V46 + V41 + V36 - V45
 GBOD W9 NORM + V9 - V51 + V50 + V24 + V48 + V49
 GBOD W10 NORM + V10 - V54 + V52 - V53 + V31 - V50
 GBOD W11 NORM + V11 - V57 + V55 - V56 + V35 + V53
 GBOD W12 NORM + V12 - V60 + V59 + V45 + V56 + V58
 GBOD B001 NORM + V139 - A001 + A007 - A00F - A005 + A006
 GBOD B002 NORM + V143 - A002 + A008 - A00H - A007 - A00T
 GBOD B003 NORM - V167 + A003 + A00B - A009 - A008 + A00A
 GBOD B005 NORM - A00S + A00R + A00C - A00L + A013
 GBOD B006 NORM - A00R + A00Q + A00T - A00I + A01B
 GBOD B007 NORM - A00Q + A00P - A00A + A00J - V170
 GBOD B008 NORM - A00P + A00O + A00U + A00K - V177
 GBOD B009 NORM + A00V - A014 + A012 - A00X + A010 + A011
 GBOD B00A NORM + A00W - A016 - A00Z - A00Y - A012 - A015
 GBOD B00B NORM + A01C + A018 - A01D - A01E + A01K - A01A
 GBOD B00C NORM + A01F - A01G - A01K - A01L - A01I - A01J
 GBOD B00D NORM - A00V + A01H + A01O + A01N + A01M + A01P
 GBOD B00E NORM - A00W + A019 + A01R + A01Q - A01O + A01S
 GBOD B00F NORM + A01D - A01R - A01U - A01V - A01T + A017
 GBOD B00G NORM + A014 - A01W - A021 + A023 - A020 - A024
 GBOD B00H NORM + A016 - A01X + A01Z + A01Y + A021 + A022
 SETA s1 p Q163
 SETA s1 p Q164
 SETA s1 p Q165
 SETA s1 p Q166
 SETA s1 p Q167
 SETA s1 p Q168
 SETA s1 p Q169
 SETA s1 p Q170
 SETA s1 p Q171
 SETA s1 p Q172
 SETA s1 p Q173
 SETA s1 p Q174
 SETA s1 p Q175
 SETA s1 p Q176
 SETA s1 p Q245
 SETA s1 p Q246
 SETA s1 p P00P
 SETA s1 p P00R
 SETA s1 p D019
 SETA s1 p D01A
 SETA s1 p D01C
 SETA s1 l L03Q
 SETA s1 l U258
 SETA s1 l U260
 SETA s1 l U262
 SETA s1 l U272
 SETA s1 l U371
 SETA s1 l U373
 SETA s1 l U374
 SETA s1 l L016
 SETA s1 l L038
 SETA s1 l L03C
 SETA s1 c U265
 SETA s1 c U270
 SETA s1 c U279
 SETA s1 s V139
 SETA s1 s V143
 SETA s1 s V167
 SETA b p P3
 SETA b p P4
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 ELTY all HE20R
 plot ld BLADE k
 plus p BLADE b
 plus s IND m
